v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {CONTROL — PDK symbols; nets use named labels} 80 -190 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -570 0 0 {name=MLB0_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -600 0 0 {name=p1 lab=b0bar}
C {devices/lab_pin.sym} 100 -570 0 0 {name=p2 lab=b0}
C {devices/lab_pin.sym} 140 -540 0 0 {name=p3 lab=0}
C {devices/lab_pin.sym} 140 -570 0 0 {name=p4 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -570 0 0 {name=MLB0_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -540 0 0 {name=p5 lab=b0bar}
C {devices/lab_pin.sym} 380 -570 0 0 {name=p6 lab=b0}
C {devices/lab_pin.sym} 420 -600 0 0 {name=p7 lab=vctrl}
C {devices/lab_pin.sym} 420 -570 0 0 {name=p8 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 680 -570 0 0 {name=MLS0_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -600 0 0 {name=p9 lab=s0bar}
C {devices/lab_pin.sym} 660 -570 0 0 {name=p10 lab=b0}
C {devices/lab_pin.sym} 700 -540 0 0 {name=p11 lab=0}
C {devices/lab_pin.sym} 700 -570 0 0 {name=p12 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 960 -570 0 0 {name=MLS0_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -600 0 0 {name=p13 lab=s0}
C {devices/lab_pin.sym} 940 -570 0 0 {name=p14 lab=b0bar}
C {devices/lab_pin.sym} 980 -540 0 0 {name=p15 lab=0}
C {devices/lab_pin.sym} 980 -570 0 0 {name=p16 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1240 -570 0 0 {name=MLS0_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -540 0 0 {name=p17 lab=s0bar}
C {devices/lab_pin.sym} 1220 -570 0 0 {name=p18 lab=s0}
C {devices/lab_pin.sym} 1260 -600 0 0 {name=p19 lab=vdd}
C {devices/lab_pin.sym} 1260 -570 0 0 {name=p20 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 1520 -570 0 0 {name=MLS0_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -540 0 0 {name=p21 lab=s0}
C {devices/lab_pin.sym} 1500 -570 0 0 {name=p22 lab=s0bar}
C {devices/lab_pin.sym} 1540 -600 0 0 {name=p23 lab=vdd}
C {devices/lab_pin.sym} 1540 -570 0 0 {name=p24 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1800 -570 0 0 {name=MLB1_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -600 0 0 {name=p25 lab=b1bar}
C {devices/lab_pin.sym} 1780 -570 0 0 {name=p26 lab=b1}
C {devices/lab_pin.sym} 1820 -540 0 0 {name=p27 lab=0}
C {devices/lab_pin.sym} 1820 -570 0 0 {name=p28 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 2080 -570 0 0 {name=MLB1_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -540 0 0 {name=p29 lab=b1bar}
C {devices/lab_pin.sym} 2060 -570 0 0 {name=p30 lab=b1}
C {devices/lab_pin.sym} 2100 -600 0 0 {name=p31 lab=vctrl}
C {devices/lab_pin.sym} 2100 -570 0 0 {name=p32 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 120 -760 0 0 {name=MLS1_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -790 0 0 {name=p33 lab=s1bar}
C {devices/lab_pin.sym} 100 -760 0 0 {name=p34 lab=b1}
C {devices/lab_pin.sym} 140 -730 0 0 {name=p35 lab=0}
C {devices/lab_pin.sym} 140 -760 0 0 {name=p36 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 400 -760 0 0 {name=MLS1_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -790 0 0 {name=p37 lab=s1}
C {devices/lab_pin.sym} 380 -760 0 0 {name=p38 lab=b1bar}
C {devices/lab_pin.sym} 420 -730 0 0 {name=p39 lab=0}
C {devices/lab_pin.sym} 420 -760 0 0 {name=p40 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 680 -760 0 0 {name=MLS1_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -730 0 0 {name=p41 lab=s1bar}
C {devices/lab_pin.sym} 660 -760 0 0 {name=p42 lab=s1}
C {devices/lab_pin.sym} 700 -790 0 0 {name=p43 lab=vdd}
C {devices/lab_pin.sym} 700 -760 0 0 {name=p44 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 960 -760 0 0 {name=MLS1_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -730 0 0 {name=p45 lab=s1}
C {devices/lab_pin.sym} 940 -760 0 0 {name=p46 lab=s1bar}
C {devices/lab_pin.sym} 980 -790 0 0 {name=p47 lab=vdd}
C {devices/lab_pin.sym} 980 -760 0 0 {name=p48 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1240 -760 0 0 {name=MLB2_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -790 0 0 {name=p49 lab=b2bar}
C {devices/lab_pin.sym} 1220 -760 0 0 {name=p50 lab=b2}
C {devices/lab_pin.sym} 1260 -730 0 0 {name=p51 lab=0}
C {devices/lab_pin.sym} 1260 -760 0 0 {name=p52 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1520 -760 0 0 {name=MLB2_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -730 0 0 {name=p53 lab=b2bar}
C {devices/lab_pin.sym} 1500 -760 0 0 {name=p54 lab=b2}
C {devices/lab_pin.sym} 1540 -790 0 0 {name=p55 lab=vctrl}
C {devices/lab_pin.sym} 1540 -760 0 0 {name=p56 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 1800 -760 0 0 {name=MLS2_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -790 0 0 {name=p57 lab=s2bar}
C {devices/lab_pin.sym} 1780 -760 0 0 {name=p58 lab=b2}
C {devices/lab_pin.sym} 1820 -730 0 0 {name=p59 lab=0}
C {devices/lab_pin.sym} 1820 -760 0 0 {name=p60 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 2080 -760 0 0 {name=MLS2_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -790 0 0 {name=p61 lab=s2}
C {devices/lab_pin.sym} 2060 -760 0 0 {name=p62 lab=b2bar}
C {devices/lab_pin.sym} 2100 -730 0 0 {name=p63 lab=0}
C {devices/lab_pin.sym} 2100 -760 0 0 {name=p64 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 120 -950 0 0 {name=MLS2_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -920 0 0 {name=p65 lab=s2bar}
C {devices/lab_pin.sym} 100 -950 0 0 {name=p66 lab=s2}
C {devices/lab_pin.sym} 140 -980 0 0 {name=p67 lab=vdd}
C {devices/lab_pin.sym} 140 -950 0 0 {name=p68 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 400 -950 0 0 {name=MLS2_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -920 0 0 {name=p69 lab=s2}
C {devices/lab_pin.sym} 380 -950 0 0 {name=p70 lab=s2bar}
C {devices/lab_pin.sym} 420 -980 0 0 {name=p71 lab=vdd}
C {devices/lab_pin.sym} 420 -950 0 0 {name=p72 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 680 -950 0 0 {name=MLB3_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -980 0 0 {name=p73 lab=b3bar}
C {devices/lab_pin.sym} 660 -950 0 0 {name=p74 lab=b3}
C {devices/lab_pin.sym} 700 -920 0 0 {name=p75 lab=0}
C {devices/lab_pin.sym} 700 -950 0 0 {name=p76 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 960 -950 0 0 {name=MLB3_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -920 0 0 {name=p77 lab=b3bar}
C {devices/lab_pin.sym} 940 -950 0 0 {name=p78 lab=b3}
C {devices/lab_pin.sym} 980 -980 0 0 {name=p79 lab=vctrl}
C {devices/lab_pin.sym} 980 -950 0 0 {name=p80 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 1240 -950 0 0 {name=MLS3_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -980 0 0 {name=p81 lab=s3bar}
C {devices/lab_pin.sym} 1220 -950 0 0 {name=p82 lab=b3}
C {devices/lab_pin.sym} 1260 -920 0 0 {name=p83 lab=0}
C {devices/lab_pin.sym} 1260 -950 0 0 {name=p84 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 1520 -950 0 0 {name=MLS3_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -980 0 0 {name=p85 lab=s3}
C {devices/lab_pin.sym} 1500 -950 0 0 {name=p86 lab=b3bar}
C {devices/lab_pin.sym} 1540 -920 0 0 {name=p87 lab=0}
C {devices/lab_pin.sym} 1540 -950 0 0 {name=p88 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1800 -950 0 0 {name=MLS3_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -920 0 0 {name=p89 lab=s3bar}
C {devices/lab_pin.sym} 1780 -950 0 0 {name=p90 lab=s3}
C {devices/lab_pin.sym} 1820 -980 0 0 {name=p91 lab=vdd}
C {devices/lab_pin.sym} 1820 -950 0 0 {name=p92 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2080 -950 0 0 {name=MLS3_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -920 0 0 {name=p93 lab=s3}
C {devices/lab_pin.sym} 2060 -950 0 0 {name=p94 lab=s3bar}
C {devices/lab_pin.sym} 2100 -980 0 0 {name=p95 lab=vdd}
C {devices/lab_pin.sym} 2100 -950 0 0 {name=p96 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 120 -1140 0 0 {name=MLB4_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1170 0 0 {name=p97 lab=b4bar}
C {devices/lab_pin.sym} 100 -1140 0 0 {name=p98 lab=b4}
C {devices/lab_pin.sym} 140 -1110 0 0 {name=p99 lab=0}
C {devices/lab_pin.sym} 140 -1140 0 0 {name=p100 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -1140 0 0 {name=MLB4_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1110 0 0 {name=p101 lab=b4bar}
C {devices/lab_pin.sym} 380 -1140 0 0 {name=p102 lab=b4}
C {devices/lab_pin.sym} 420 -1170 0 0 {name=p103 lab=vctrl}
C {devices/lab_pin.sym} 420 -1140 0 0 {name=p104 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 680 -1140 0 0 {name=MLS4_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1170 0 0 {name=p105 lab=s4bar}
C {devices/lab_pin.sym} 660 -1140 0 0 {name=p106 lab=b4}
C {devices/lab_pin.sym} 700 -1110 0 0 {name=p107 lab=0}
C {devices/lab_pin.sym} 700 -1140 0 0 {name=p108 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 960 -1140 0 0 {name=MLS4_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1170 0 0 {name=p109 lab=s4}
C {devices/lab_pin.sym} 940 -1140 0 0 {name=p110 lab=b4bar}
C {devices/lab_pin.sym} 980 -1110 0 0 {name=p111 lab=0}
C {devices/lab_pin.sym} 980 -1140 0 0 {name=p112 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1240 -1140 0 0 {name=MLS4_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1110 0 0 {name=p113 lab=s4bar}
C {devices/lab_pin.sym} 1220 -1140 0 0 {name=p114 lab=s4}
C {devices/lab_pin.sym} 1260 -1170 0 0 {name=p115 lab=vdd}
C {devices/lab_pin.sym} 1260 -1140 0 0 {name=p116 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 1520 -1140 0 0 {name=MLS4_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1110 0 0 {name=p117 lab=s4}
C {devices/lab_pin.sym} 1500 -1140 0 0 {name=p118 lab=s4bar}
C {devices/lab_pin.sym} 1540 -1170 0 0 {name=p119 lab=vdd}
C {devices/lab_pin.sym} 1540 -1140 0 0 {name=p120 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1800 -1140 0 0 {name=MLB5_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1170 0 0 {name=p121 lab=b5bar}
C {devices/lab_pin.sym} 1780 -1140 0 0 {name=p122 lab=b5}
C {devices/lab_pin.sym} 1820 -1110 0 0 {name=p123 lab=0}
C {devices/lab_pin.sym} 1820 -1140 0 0 {name=p124 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 2080 -1140 0 0 {name=MLB5_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1110 0 0 {name=p125 lab=b5bar}
C {devices/lab_pin.sym} 2060 -1140 0 0 {name=p126 lab=b5}
C {devices/lab_pin.sym} 2100 -1170 0 0 {name=p127 lab=vctrl}
C {devices/lab_pin.sym} 2100 -1140 0 0 {name=p128 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 120 -1330 0 0 {name=MLS5_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1360 0 0 {name=p129 lab=s5bar}
C {devices/lab_pin.sym} 100 -1330 0 0 {name=p130 lab=b5}
C {devices/lab_pin.sym} 140 -1300 0 0 {name=p131 lab=0}
C {devices/lab_pin.sym} 140 -1330 0 0 {name=p132 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 400 -1330 0 0 {name=MLS5_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1360 0 0 {name=p133 lab=s5}
C {devices/lab_pin.sym} 380 -1330 0 0 {name=p134 lab=b5bar}
C {devices/lab_pin.sym} 420 -1300 0 0 {name=p135 lab=0}
C {devices/lab_pin.sym} 420 -1330 0 0 {name=p136 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 680 -1330 0 0 {name=MLS5_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1300 0 0 {name=p137 lab=s5bar}
C {devices/lab_pin.sym} 660 -1330 0 0 {name=p138 lab=s5}
C {devices/lab_pin.sym} 700 -1360 0 0 {name=p139 lab=vdd}
C {devices/lab_pin.sym} 700 -1330 0 0 {name=p140 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 960 -1330 0 0 {name=MLS5_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1300 0 0 {name=p141 lab=s5}
C {devices/lab_pin.sym} 940 -1330 0 0 {name=p142 lab=s5bar}
C {devices/lab_pin.sym} 980 -1360 0 0 {name=p143 lab=vdd}
C {devices/lab_pin.sym} 980 -1330 0 0 {name=p144 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1240 -1330 0 0 {name=MLB6_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1360 0 0 {name=p145 lab=b6bar}
C {devices/lab_pin.sym} 1220 -1330 0 0 {name=p146 lab=b6}
C {devices/lab_pin.sym} 1260 -1300 0 0 {name=p147 lab=0}
C {devices/lab_pin.sym} 1260 -1330 0 0 {name=p148 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1520 -1330 0 0 {name=MLB6_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1300 0 0 {name=p149 lab=b6bar}
C {devices/lab_pin.sym} 1500 -1330 0 0 {name=p150 lab=b6}
C {devices/lab_pin.sym} 1540 -1360 0 0 {name=p151 lab=vctrl}
C {devices/lab_pin.sym} 1540 -1330 0 0 {name=p152 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 1800 -1330 0 0 {name=MLS6_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1360 0 0 {name=p153 lab=s6bar}
C {devices/lab_pin.sym} 1780 -1330 0 0 {name=p154 lab=b6}
C {devices/lab_pin.sym} 1820 -1300 0 0 {name=p155 lab=0}
C {devices/lab_pin.sym} 1820 -1330 0 0 {name=p156 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 2080 -1330 0 0 {name=MLS6_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1360 0 0 {name=p157 lab=s6}
C {devices/lab_pin.sym} 2060 -1330 0 0 {name=p158 lab=b6bar}
C {devices/lab_pin.sym} 2100 -1300 0 0 {name=p159 lab=0}
C {devices/lab_pin.sym} 2100 -1330 0 0 {name=p160 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 120 -1520 0 0 {name=MLS6_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1490 0 0 {name=p161 lab=s6bar}
C {devices/lab_pin.sym} 100 -1520 0 0 {name=p162 lab=s6}
C {devices/lab_pin.sym} 140 -1550 0 0 {name=p163 lab=vdd}
C {devices/lab_pin.sym} 140 -1520 0 0 {name=p164 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 400 -1520 0 0 {name=MLS6_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1490 0 0 {name=p165 lab=s6}
C {devices/lab_pin.sym} 380 -1520 0 0 {name=p166 lab=s6bar}
C {devices/lab_pin.sym} 420 -1550 0 0 {name=p167 lab=vdd}
C {devices/lab_pin.sym} 420 -1520 0 0 {name=p168 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 680 -1520 0 0 {name=MLB7_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1550 0 0 {name=p169 lab=b7bar}
C {devices/lab_pin.sym} 660 -1520 0 0 {name=p170 lab=b7}
C {devices/lab_pin.sym} 700 -1490 0 0 {name=p171 lab=0}
C {devices/lab_pin.sym} 700 -1520 0 0 {name=p172 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 960 -1520 0 0 {name=MLB7_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1490 0 0 {name=p173 lab=b7bar}
C {devices/lab_pin.sym} 940 -1520 0 0 {name=p174 lab=b7}
C {devices/lab_pin.sym} 980 -1550 0 0 {name=p175 lab=vctrl}
C {devices/lab_pin.sym} 980 -1520 0 0 {name=p176 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 1240 -1520 0 0 {name=MLS7_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1550 0 0 {name=p177 lab=s7bar}
C {devices/lab_pin.sym} 1220 -1520 0 0 {name=p178 lab=b7}
C {devices/lab_pin.sym} 1260 -1490 0 0 {name=p179 lab=0}
C {devices/lab_pin.sym} 1260 -1520 0 0 {name=p180 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 1520 -1520 0 0 {name=MLS7_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1550 0 0 {name=p181 lab=s7}
C {devices/lab_pin.sym} 1500 -1520 0 0 {name=p182 lab=b7bar}
C {devices/lab_pin.sym} 1540 -1490 0 0 {name=p183 lab=0}
C {devices/lab_pin.sym} 1540 -1520 0 0 {name=p184 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1800 -1520 0 0 {name=MLS7_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1490 0 0 {name=p185 lab=s7bar}
C {devices/lab_pin.sym} 1780 -1520 0 0 {name=p186 lab=s7}
C {devices/lab_pin.sym} 1820 -1550 0 0 {name=p187 lab=vdd}
C {devices/lab_pin.sym} 1820 -1520 0 0 {name=p188 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2080 -1520 0 0 {name=MLS7_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1490 0 0 {name=p189 lab=s7}
C {devices/lab_pin.sym} 2060 -1520 0 0 {name=p190 lab=s7bar}
C {devices/lab_pin.sym} 2100 -1550 0 0 {name=p191 lab=vdd}
C {devices/lab_pin.sym} 2100 -1520 0 0 {name=p192 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 120 -1710 0 0 {name=MLB8_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1740 0 0 {name=p193 lab=b8bar}
C {devices/lab_pin.sym} 100 -1710 0 0 {name=p194 lab=b8}
C {devices/lab_pin.sym} 140 -1680 0 0 {name=p195 lab=0}
C {devices/lab_pin.sym} 140 -1710 0 0 {name=p196 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -1710 0 0 {name=MLB8_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1680 0 0 {name=p197 lab=b8bar}
C {devices/lab_pin.sym} 380 -1710 0 0 {name=p198 lab=b8}
C {devices/lab_pin.sym} 420 -1740 0 0 {name=p199 lab=vctrl}
C {devices/lab_pin.sym} 420 -1710 0 0 {name=p200 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 680 -1710 0 0 {name=MLS8_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1740 0 0 {name=p201 lab=s8bar}
C {devices/lab_pin.sym} 660 -1710 0 0 {name=p202 lab=b8}
C {devices/lab_pin.sym} 700 -1680 0 0 {name=p203 lab=0}
C {devices/lab_pin.sym} 700 -1710 0 0 {name=p204 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 960 -1710 0 0 {name=MLS8_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1740 0 0 {name=p205 lab=s8}
C {devices/lab_pin.sym} 940 -1710 0 0 {name=p206 lab=b8bar}
C {devices/lab_pin.sym} 980 -1680 0 0 {name=p207 lab=0}
C {devices/lab_pin.sym} 980 -1710 0 0 {name=p208 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 1240 -1710 0 0 {name=MLS8_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1680 0 0 {name=p209 lab=s8bar}
C {devices/lab_pin.sym} 1220 -1710 0 0 {name=p210 lab=s8}
C {devices/lab_pin.sym} 1260 -1740 0 0 {name=p211 lab=vdd}
C {devices/lab_pin.sym} 1260 -1710 0 0 {name=p212 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 1520 -1710 0 0 {name=MLS8_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1680 0 0 {name=p213 lab=s8}
C {devices/lab_pin.sym} 1500 -1710 0 0 {name=p214 lab=s8bar}
C {devices/lab_pin.sym} 1540 -1740 0 0 {name=p215 lab=vdd}
C {devices/lab_pin.sym} 1540 -1710 0 0 {name=p216 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1800 -1710 0 0 {name=MLMAIN_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1740 0 0 {name=p217 lab=mainbar}
C {devices/lab_pin.sym} 1780 -1710 0 0 {name=p218 lab=main}
C {devices/lab_pin.sym} 1820 -1680 0 0 {name=p219 lab=0}
C {devices/lab_pin.sym} 1820 -1710 0 0 {name=p220 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 2080 -1710 0 0 {name=MLMAIN_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1680 0 0 {name=p221 lab=mainbar}
C {devices/lab_pin.sym} 2060 -1710 0 0 {name=p222 lab=main}
C {devices/lab_pin.sym} 2100 -1740 0 0 {name=p223 lab=vctrl}
C {devices/lab_pin.sym} 2100 -1710 0 0 {name=p224 lab=vctrl}
C {sky130_fd_pr/nfet_01v8.sym} 120 -1900 0 0 {name=MLSMAIN_N0 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1930 0 0 {name=p225 lab=smainbar}
C {devices/lab_pin.sym} 100 -1900 0 0 {name=p226 lab=main}
C {devices/lab_pin.sym} 140 -1870 0 0 {name=p227 lab=0}
C {devices/lab_pin.sym} 140 -1900 0 0 {name=p228 lab=0}
C {sky130_fd_pr/nfet_01v8.sym} 400 -1900 0 0 {name=MLSMAIN_N1 L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1930 0 0 {name=p229 lab=smain}
C {devices/lab_pin.sym} 380 -1900 0 0 {name=p230 lab=mainbar}
C {devices/lab_pin.sym} 420 -1870 0 0 {name=p231 lab=0}
C {devices/lab_pin.sym} 420 -1900 0 0 {name=p232 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 680 -1900 0 0 {name=MLSMAIN_P0 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1870 0 0 {name=p233 lab=smainbar}
C {devices/lab_pin.sym} 660 -1900 0 0 {name=p234 lab=smain}
C {devices/lab_pin.sym} 700 -1930 0 0 {name=p235 lab=vdd}
C {devices/lab_pin.sym} 700 -1900 0 0 {name=p236 lab=vdd}
C {sky130_fd_pr/pfet_01v8.sym} 960 -1900 0 0 {name=MLSMAIN_P1 L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1870 0 0 {name=p237 lab=smain}
C {devices/lab_pin.sym} 940 -1900 0 0 {name=p238 lab=smainbar}
C {devices/lab_pin.sym} 980 -1930 0 0 {name=p239 lab=vdd}
C {devices/lab_pin.sym} 980 -1900 0 0 {name=p240 lab=vdd}
T {RING — PDK symbols; nets use named labels} 80 -2090 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -2470 0 0 {name=MINV0_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -2500 0 0 {name=p241 lab=d0}
C {devices/lab_pin.sym} 100 -2470 0 0 {name=p242 lab=n2}
C {devices/lab_pin.sym} 140 -2440 0 0 {name=p243 lab=0}
C {devices/lab_pin.sym} 140 -2470 0 0 {name=p244 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -2470 0 0 {name=MINV0_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -2440 0 0 {name=p245 lab=d0}
C {devices/lab_pin.sym} 380 -2470 0 0 {name=p246 lab=n2}
C {devices/lab_pin.sym} 420 -2500 0 0 {name=p247 lab=vdd}
C {devices/lab_pin.sym} 420 -2470 0 0 {name=p248 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -2660 0 0 0.35 0.35 {}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 120 -3040 0 0 {name=RRDELAY0 model=res_xhigh_po_1p41 L=330 mult=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -3070 0 0 {name=p249 lab=d0}
C {devices/lab_pin.sym} 120 -3010 0 0 {name=p250 lab=n0}
C {devices/lab_pin.sym} 100 -3040 0 0 {name=p251 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -3040 0 0 {name=CCBASE0 model=cap_mim_m3_2 W=15.7 L=15.7 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -3070 0 0 {name=p252 lab=n0}
C {devices/lab_pin.sym} 400 -3010 0 0 {name=p253 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -3230 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3610 0 0 {name=MMAIN0_N L=0.15 W=8 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -3640 0 0 {name=p254 lab=n0}
C {devices/lab_pin.sym} 100 -3610 0 0 {name=p255 lab=smain}
C {devices/lab_pin.sym} 140 -3580 0 0 {name=p256 lab=bank0}
C {devices/lab_pin.sym} 140 -3610 0 0 {name=p257 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -3610 0 0 {name=MMAIN0_P L=0.15 W=16 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -3580 0 0 {name=p258 lab=n0}
C {devices/lab_pin.sym} 380 -3610 0 0 {name=p259 lab=smainbar}
C {devices/lab_pin.sym} 420 -3640 0 0 {name=p260 lab=bank0}
C {devices/lab_pin.sym} 420 -3610 0 0 {name=p261 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -3800 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4180 0 0 {name=MSW0_0_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -4210 0 0 {name=p262 lab=bank0}
C {devices/lab_pin.sym} 100 -4180 0 0 {name=p263 lab=s0}
C {devices/lab_pin.sym} 140 -4150 0 0 {name=p264 lab=cap0_0}
C {devices/lab_pin.sym} 140 -4180 0 0 {name=p265 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -4180 0 0 {name=MSW0_0_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -4150 0 0 {name=p266 lab=bank0}
C {devices/lab_pin.sym} 380 -4180 0 0 {name=p267 lab=s0bar}
C {devices/lab_pin.sym} 420 -4210 0 0 {name=p268 lab=cap0_0}
C {devices/lab_pin.sym} 420 -4180 0 0 {name=p269 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -4370 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -4750 0 0 {name=CC0_0_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -4780 0 0 {name=p270 lab=cap0_0}
C {devices/lab_pin.sym} 120 -4720 0 0 {name=p271 lab=mid0_0_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -4750 0 0 {name=CC0_0_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -4780 0 0 {name=p272 lab=mid0_0_0_0}
C {devices/lab_pin.sym} 400 -4720 0 0 {name=p273 lab=mid0_0_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -4750 0 0 {name=CC0_0_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -4780 0 0 {name=p274 lab=mid0_0_0_1}
C {devices/lab_pin.sym} 680 -4720 0 0 {name=p275 lab=mid0_0_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -4750 0 0 {name=CC0_0_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -4780 0 0 {name=p276 lab=mid0_0_0_2}
C {devices/lab_pin.sym} 960 -4720 0 0 {name=p277 lab=mid0_0_0_3}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -4750 0 0 {name=CC0_0_0_4 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -4780 0 0 {name=p278 lab=mid0_0_0_3}
C {devices/lab_pin.sym} 1240 -4720 0 0 {name=p279 lab=mid0_0_0_4}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -4750 0 0 {name=CC0_0_0_5 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -4780 0 0 {name=p280 lab=mid0_0_0_4}
C {devices/lab_pin.sym} 1520 -4720 0 0 {name=p281 lab=mid0_0_0_5}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -4750 0 0 {name=CC0_0_0_6 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -4780 0 0 {name=p282 lab=mid0_0_0_5}
C {devices/lab_pin.sym} 1800 -4720 0 0 {name=p283 lab=mid0_0_0_6}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -4750 0 0 {name=CC0_0_0_7 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -4780 0 0 {name=p284 lab=mid0_0_0_6}
C {devices/lab_pin.sym} 2080 -4720 0 0 {name=p285 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -4940 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -5320 0 0 {name=MSW0_1_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -5350 0 0 {name=p286 lab=bank0}
C {devices/lab_pin.sym} 100 -5320 0 0 {name=p287 lab=s1}
C {devices/lab_pin.sym} 140 -5290 0 0 {name=p288 lab=cap0_1}
C {devices/lab_pin.sym} 140 -5320 0 0 {name=p289 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -5320 0 0 {name=MSW0_1_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -5290 0 0 {name=p290 lab=bank0}
C {devices/lab_pin.sym} 380 -5320 0 0 {name=p291 lab=s1bar}
C {devices/lab_pin.sym} 420 -5350 0 0 {name=p292 lab=cap0_1}
C {devices/lab_pin.sym} 420 -5320 0 0 {name=p293 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -5510 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -5890 0 0 {name=CC0_1_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -5920 0 0 {name=p294 lab=cap0_1}
C {devices/lab_pin.sym} 120 -5860 0 0 {name=p295 lab=mid0_1_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -5890 0 0 {name=CC0_1_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -5920 0 0 {name=p296 lab=mid0_1_0_0}
C {devices/lab_pin.sym} 400 -5860 0 0 {name=p297 lab=mid0_1_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -5890 0 0 {name=CC0_1_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -5920 0 0 {name=p298 lab=mid0_1_0_1}
C {devices/lab_pin.sym} 680 -5860 0 0 {name=p299 lab=mid0_1_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -5890 0 0 {name=CC0_1_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -5920 0 0 {name=p300 lab=mid0_1_0_2}
C {devices/lab_pin.sym} 960 -5860 0 0 {name=p301 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -6080 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -6460 0 0 {name=MSW0_2_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -6490 0 0 {name=p302 lab=bank0}
C {devices/lab_pin.sym} 100 -6460 0 0 {name=p303 lab=s2}
C {devices/lab_pin.sym} 140 -6430 0 0 {name=p304 lab=cap0_2}
C {devices/lab_pin.sym} 140 -6460 0 0 {name=p305 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -6460 0 0 {name=MSW0_2_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -6430 0 0 {name=p306 lab=bank0}
C {devices/lab_pin.sym} 380 -6460 0 0 {name=p307 lab=s2bar}
C {devices/lab_pin.sym} 420 -6490 0 0 {name=p308 lab=cap0_2}
C {devices/lab_pin.sym} 420 -6460 0 0 {name=p309 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -6650 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -7030 0 0 {name=CC0_2_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -7060 0 0 {name=p310 lab=cap0_2}
C {devices/lab_pin.sym} 120 -7000 0 0 {name=p311 lab=mid0_2_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -7030 0 0 {name=CC0_2_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -7060 0 0 {name=p312 lab=mid0_2_0_0}
C {devices/lab_pin.sym} 400 -7000 0 0 {name=p313 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -7220 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -7600 0 0 {name=MSW0_3_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -7630 0 0 {name=p314 lab=bank0}
C {devices/lab_pin.sym} 100 -7600 0 0 {name=p315 lab=s3}
C {devices/lab_pin.sym} 140 -7570 0 0 {name=p316 lab=cap0_3}
C {devices/lab_pin.sym} 140 -7600 0 0 {name=p317 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -7600 0 0 {name=MSW0_3_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -7570 0 0 {name=p318 lab=bank0}
C {devices/lab_pin.sym} 380 -7600 0 0 {name=p319 lab=s3bar}
C {devices/lab_pin.sym} 420 -7630 0 0 {name=p320 lab=cap0_3}
C {devices/lab_pin.sym} 420 -7600 0 0 {name=p321 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -7790 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -8170 0 0 {name=CC0_3_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -8200 0 0 {name=p322 lab=cap0_3}
C {devices/lab_pin.sym} 120 -8140 0 0 {name=p323 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -8360 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -8740 0 0 {name=MSW0_4_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -8770 0 0 {name=p324 lab=bank0}
C {devices/lab_pin.sym} 100 -8740 0 0 {name=p325 lab=s4}
C {devices/lab_pin.sym} 140 -8710 0 0 {name=p326 lab=cap0_4}
C {devices/lab_pin.sym} 140 -8740 0 0 {name=p327 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -8740 0 0 {name=MSW0_4_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -8710 0 0 {name=p328 lab=bank0}
C {devices/lab_pin.sym} 380 -8740 0 0 {name=p329 lab=s4bar}
C {devices/lab_pin.sym} 420 -8770 0 0 {name=p330 lab=cap0_4}
C {devices/lab_pin.sym} 420 -8740 0 0 {name=p331 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -8930 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -9310 0 0 {name=CC0_4_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -9340 0 0 {name=p332 lab=cap0_4}
C {devices/lab_pin.sym} 120 -9280 0 0 {name=p333 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -9310 0 0 {name=CC0_4_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -9340 0 0 {name=p334 lab=cap0_4}
C {devices/lab_pin.sym} 400 -9280 0 0 {name=p335 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -9500 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -9880 0 0 {name=MSW0_5_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -9910 0 0 {name=p336 lab=bank0}
C {devices/lab_pin.sym} 100 -9880 0 0 {name=p337 lab=s5}
C {devices/lab_pin.sym} 140 -9850 0 0 {name=p338 lab=cap0_5}
C {devices/lab_pin.sym} 140 -9880 0 0 {name=p339 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -9880 0 0 {name=MSW0_5_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -9850 0 0 {name=p340 lab=bank0}
C {devices/lab_pin.sym} 380 -9880 0 0 {name=p341 lab=s5bar}
C {devices/lab_pin.sym} 420 -9910 0 0 {name=p342 lab=cap0_5}
C {devices/lab_pin.sym} 420 -9880 0 0 {name=p343 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -10070 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -10450 0 0 {name=CC0_5_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -10480 0 0 {name=p344 lab=cap0_5}
C {devices/lab_pin.sym} 120 -10420 0 0 {name=p345 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -10450 0 0 {name=CC0_5_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -10480 0 0 {name=p346 lab=cap0_5}
C {devices/lab_pin.sym} 400 -10420 0 0 {name=p347 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -10450 0 0 {name=CC0_5_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -10480 0 0 {name=p348 lab=cap0_5}
C {devices/lab_pin.sym} 680 -10420 0 0 {name=p349 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -10450 0 0 {name=CC0_5_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -10480 0 0 {name=p350 lab=cap0_5}
C {devices/lab_pin.sym} 960 -10420 0 0 {name=p351 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -10640 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -11020 0 0 {name=MSW0_6_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -11050 0 0 {name=p352 lab=bank0}
C {devices/lab_pin.sym} 100 -11020 0 0 {name=p353 lab=s6}
C {devices/lab_pin.sym} 140 -10990 0 0 {name=p354 lab=cap0_6}
C {devices/lab_pin.sym} 140 -11020 0 0 {name=p355 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -11020 0 0 {name=MSW0_6_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -10990 0 0 {name=p356 lab=bank0}
C {devices/lab_pin.sym} 380 -11020 0 0 {name=p357 lab=s6bar}
C {devices/lab_pin.sym} 420 -11050 0 0 {name=p358 lab=cap0_6}
C {devices/lab_pin.sym} 420 -11020 0 0 {name=p359 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -11210 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -11590 0 0 {name=CC0_6_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -11620 0 0 {name=p360 lab=cap0_6}
C {devices/lab_pin.sym} 120 -11560 0 0 {name=p361 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -11590 0 0 {name=CC0_6_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -11620 0 0 {name=p362 lab=cap0_6}
C {devices/lab_pin.sym} 400 -11560 0 0 {name=p363 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -11590 0 0 {name=CC0_6_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -11620 0 0 {name=p364 lab=cap0_6}
C {devices/lab_pin.sym} 680 -11560 0 0 {name=p365 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -11590 0 0 {name=CC0_6_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -11620 0 0 {name=p366 lab=cap0_6}
C {devices/lab_pin.sym} 960 -11560 0 0 {name=p367 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -11590 0 0 {name=CC0_6_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -11620 0 0 {name=p368 lab=cap0_6}
C {devices/lab_pin.sym} 1240 -11560 0 0 {name=p369 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -11590 0 0 {name=CC0_6_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -11620 0 0 {name=p370 lab=cap0_6}
C {devices/lab_pin.sym} 1520 -11560 0 0 {name=p371 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -11590 0 0 {name=CC0_6_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -11620 0 0 {name=p372 lab=cap0_6}
C {devices/lab_pin.sym} 1800 -11560 0 0 {name=p373 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -11590 0 0 {name=CC0_6_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -11620 0 0 {name=p374 lab=cap0_6}
C {devices/lab_pin.sym} 2080 -11560 0 0 {name=p375 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -11780 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -12160 0 0 {name=MSW0_7_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -12190 0 0 {name=p376 lab=bank0}
C {devices/lab_pin.sym} 100 -12160 0 0 {name=p377 lab=s7}
C {devices/lab_pin.sym} 140 -12130 0 0 {name=p378 lab=cap0_7}
C {devices/lab_pin.sym} 140 -12160 0 0 {name=p379 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -12160 0 0 {name=MSW0_7_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -12130 0 0 {name=p380 lab=bank0}
C {devices/lab_pin.sym} 380 -12160 0 0 {name=p381 lab=s7bar}
C {devices/lab_pin.sym} 420 -12190 0 0 {name=p382 lab=cap0_7}
C {devices/lab_pin.sym} 420 -12160 0 0 {name=p383 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -12350 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -12730 0 0 {name=CC0_7_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -12760 0 0 {name=p384 lab=cap0_7}
C {devices/lab_pin.sym} 120 -12700 0 0 {name=p385 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -12730 0 0 {name=CC0_7_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -12760 0 0 {name=p386 lab=cap0_7}
C {devices/lab_pin.sym} 400 -12700 0 0 {name=p387 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -12730 0 0 {name=CC0_7_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -12760 0 0 {name=p388 lab=cap0_7}
C {devices/lab_pin.sym} 680 -12700 0 0 {name=p389 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -12730 0 0 {name=CC0_7_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -12760 0 0 {name=p390 lab=cap0_7}
C {devices/lab_pin.sym} 960 -12700 0 0 {name=p391 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -12730 0 0 {name=CC0_7_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -12760 0 0 {name=p392 lab=cap0_7}
C {devices/lab_pin.sym} 1240 -12700 0 0 {name=p393 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -12730 0 0 {name=CC0_7_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -12760 0 0 {name=p394 lab=cap0_7}
C {devices/lab_pin.sym} 1520 -12700 0 0 {name=p395 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -12730 0 0 {name=CC0_7_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -12760 0 0 {name=p396 lab=cap0_7}
C {devices/lab_pin.sym} 1800 -12700 0 0 {name=p397 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -12730 0 0 {name=CC0_7_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -12760 0 0 {name=p398 lab=cap0_7}
C {devices/lab_pin.sym} 2080 -12700 0 0 {name=p399 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -12920 0 0 {name=CC0_7_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -12950 0 0 {name=p400 lab=cap0_7}
C {devices/lab_pin.sym} 120 -12890 0 0 {name=p401 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -12920 0 0 {name=CC0_7_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -12950 0 0 {name=p402 lab=cap0_7}
C {devices/lab_pin.sym} 400 -12890 0 0 {name=p403 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -12920 0 0 {name=CC0_7_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -12950 0 0 {name=p404 lab=cap0_7}
C {devices/lab_pin.sym} 680 -12890 0 0 {name=p405 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -12920 0 0 {name=CC0_7_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -12950 0 0 {name=p406 lab=cap0_7}
C {devices/lab_pin.sym} 960 -12890 0 0 {name=p407 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -12920 0 0 {name=CC0_7_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -12950 0 0 {name=p408 lab=cap0_7}
C {devices/lab_pin.sym} 1240 -12890 0 0 {name=p409 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -12920 0 0 {name=CC0_7_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -12950 0 0 {name=p410 lab=cap0_7}
C {devices/lab_pin.sym} 1520 -12890 0 0 {name=p411 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -12920 0 0 {name=CC0_7_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -12950 0 0 {name=p412 lab=cap0_7}
C {devices/lab_pin.sym} 1800 -12890 0 0 {name=p413 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -12920 0 0 {name=CC0_7_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -12950 0 0 {name=p414 lab=cap0_7}
C {devices/lab_pin.sym} 2080 -12890 0 0 {name=p415 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -13110 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -13490 0 0 {name=MSW0_8_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -13520 0 0 {name=p416 lab=bank0}
C {devices/lab_pin.sym} 100 -13490 0 0 {name=p417 lab=s8}
C {devices/lab_pin.sym} 140 -13460 0 0 {name=p418 lab=cap0_8}
C {devices/lab_pin.sym} 140 -13490 0 0 {name=p419 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -13490 0 0 {name=MSW0_8_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -13460 0 0 {name=p420 lab=bank0}
C {devices/lab_pin.sym} 380 -13490 0 0 {name=p421 lab=s8bar}
C {devices/lab_pin.sym} 420 -13520 0 0 {name=p422 lab=cap0_8}
C {devices/lab_pin.sym} 420 -13490 0 0 {name=p423 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -13680 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -14060 0 0 {name=CC0_8_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14090 0 0 {name=p424 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14030 0 0 {name=p425 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -14060 0 0 {name=CC0_8_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14090 0 0 {name=p426 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14030 0 0 {name=p427 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -14060 0 0 {name=CC0_8_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14090 0 0 {name=p428 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14030 0 0 {name=p429 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -14060 0 0 {name=CC0_8_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14090 0 0 {name=p430 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14030 0 0 {name=p431 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -14060 0 0 {name=CC0_8_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14090 0 0 {name=p432 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14030 0 0 {name=p433 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -14060 0 0 {name=CC0_8_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14090 0 0 {name=p434 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14030 0 0 {name=p435 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -14060 0 0 {name=CC0_8_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14090 0 0 {name=p436 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14030 0 0 {name=p437 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -14060 0 0 {name=CC0_8_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14090 0 0 {name=p438 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14030 0 0 {name=p439 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -14250 0 0 {name=CC0_8_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14280 0 0 {name=p440 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14220 0 0 {name=p441 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -14250 0 0 {name=CC0_8_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14280 0 0 {name=p442 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14220 0 0 {name=p443 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -14250 0 0 {name=CC0_8_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14280 0 0 {name=p444 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14220 0 0 {name=p445 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -14250 0 0 {name=CC0_8_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14280 0 0 {name=p446 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14220 0 0 {name=p447 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -14250 0 0 {name=CC0_8_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14280 0 0 {name=p448 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14220 0 0 {name=p449 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -14250 0 0 {name=CC0_8_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14280 0 0 {name=p450 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14220 0 0 {name=p451 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -14250 0 0 {name=CC0_8_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14280 0 0 {name=p452 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14220 0 0 {name=p453 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -14250 0 0 {name=CC0_8_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14280 0 0 {name=p454 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14220 0 0 {name=p455 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -14440 0 0 {name=CC0_8_16_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14470 0 0 {name=p456 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14410 0 0 {name=p457 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -14440 0 0 {name=CC0_8_17_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14470 0 0 {name=p458 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14410 0 0 {name=p459 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -14440 0 0 {name=CC0_8_18_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14470 0 0 {name=p460 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14410 0 0 {name=p461 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -14440 0 0 {name=CC0_8_19_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14470 0 0 {name=p462 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14410 0 0 {name=p463 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -14440 0 0 {name=CC0_8_20_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14470 0 0 {name=p464 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14410 0 0 {name=p465 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -14440 0 0 {name=CC0_8_21_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14470 0 0 {name=p466 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14410 0 0 {name=p467 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -14440 0 0 {name=CC0_8_22_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14470 0 0 {name=p468 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14410 0 0 {name=p469 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -14440 0 0 {name=CC0_8_23_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14470 0 0 {name=p470 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14410 0 0 {name=p471 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -14630 0 0 {name=CC0_8_24_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14660 0 0 {name=p472 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14600 0 0 {name=p473 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -14630 0 0 {name=CC0_8_25_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14660 0 0 {name=p474 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14600 0 0 {name=p475 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -14630 0 0 {name=CC0_8_26_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14660 0 0 {name=p476 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14600 0 0 {name=p477 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -14630 0 0 {name=CC0_8_27_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14660 0 0 {name=p478 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14600 0 0 {name=p479 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -14630 0 0 {name=CC0_8_28_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14660 0 0 {name=p480 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14600 0 0 {name=p481 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -14630 0 0 {name=CC0_8_29_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14660 0 0 {name=p482 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14600 0 0 {name=p483 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -14630 0 0 {name=CC0_8_30_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14660 0 0 {name=p484 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14600 0 0 {name=p485 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -14630 0 0 {name=CC0_8_31_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14660 0 0 {name=p486 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14600 0 0 {name=p487 lab=0}
T {RING — PDK symbols; nets use named labels} 80 -14820 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -15200 0 0 {name=MINV1_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -15230 0 0 {name=p488 lab=d1}
C {devices/lab_pin.sym} 100 -15200 0 0 {name=p489 lab=n0}
C {devices/lab_pin.sym} 140 -15170 0 0 {name=p490 lab=0}
C {devices/lab_pin.sym} 140 -15200 0 0 {name=p491 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -15200 0 0 {name=MINV1_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -15170 0 0 {name=p492 lab=d1}
C {devices/lab_pin.sym} 380 -15200 0 0 {name=p493 lab=n0}
C {devices/lab_pin.sym} 420 -15230 0 0 {name=p494 lab=vdd}
C {devices/lab_pin.sym} 420 -15200 0 0 {name=p495 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -15390 0 0 0.35 0.35 {}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 120 -15770 0 0 {name=RRDELAY1 model=res_xhigh_po_1p41 L=330 mult=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -15800 0 0 {name=p496 lab=d1}
C {devices/lab_pin.sym} 120 -15740 0 0 {name=p497 lab=n1}
C {devices/lab_pin.sym} 100 -15770 0 0 {name=p498 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -15770 0 0 {name=CCBASE1 model=cap_mim_m3_2 W=15.7 L=15.7 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -15800 0 0 {name=p499 lab=n1}
C {devices/lab_pin.sym} 400 -15740 0 0 {name=p500 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -15960 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -16340 0 0 {name=MMAIN1_N L=0.15 W=8 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -16370 0 0 {name=p501 lab=n1}
C {devices/lab_pin.sym} 100 -16340 0 0 {name=p502 lab=smain}
C {devices/lab_pin.sym} 140 -16310 0 0 {name=p503 lab=bank1}
C {devices/lab_pin.sym} 140 -16340 0 0 {name=p504 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -16340 0 0 {name=MMAIN1_P L=0.15 W=16 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -16310 0 0 {name=p505 lab=n1}
C {devices/lab_pin.sym} 380 -16340 0 0 {name=p506 lab=smainbar}
C {devices/lab_pin.sym} 420 -16370 0 0 {name=p507 lab=bank1}
C {devices/lab_pin.sym} 420 -16340 0 0 {name=p508 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -16530 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -16910 0 0 {name=MSW1_0_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -16940 0 0 {name=p509 lab=bank1}
C {devices/lab_pin.sym} 100 -16910 0 0 {name=p510 lab=s0}
C {devices/lab_pin.sym} 140 -16880 0 0 {name=p511 lab=cap1_0}
C {devices/lab_pin.sym} 140 -16910 0 0 {name=p512 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -16910 0 0 {name=MSW1_0_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -16880 0 0 {name=p513 lab=bank1}
C {devices/lab_pin.sym} 380 -16910 0 0 {name=p514 lab=s0bar}
C {devices/lab_pin.sym} 420 -16940 0 0 {name=p515 lab=cap1_0}
C {devices/lab_pin.sym} 420 -16910 0 0 {name=p516 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -17100 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -17480 0 0 {name=CC1_0_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -17510 0 0 {name=p517 lab=cap1_0}
C {devices/lab_pin.sym} 120 -17450 0 0 {name=p518 lab=mid1_0_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -17480 0 0 {name=CC1_0_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -17510 0 0 {name=p519 lab=mid1_0_0_0}
C {devices/lab_pin.sym} 400 -17450 0 0 {name=p520 lab=mid1_0_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -17480 0 0 {name=CC1_0_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -17510 0 0 {name=p521 lab=mid1_0_0_1}
C {devices/lab_pin.sym} 680 -17450 0 0 {name=p522 lab=mid1_0_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -17480 0 0 {name=CC1_0_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -17510 0 0 {name=p523 lab=mid1_0_0_2}
C {devices/lab_pin.sym} 960 -17450 0 0 {name=p524 lab=mid1_0_0_3}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -17480 0 0 {name=CC1_0_0_4 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -17510 0 0 {name=p525 lab=mid1_0_0_3}
C {devices/lab_pin.sym} 1240 -17450 0 0 {name=p526 lab=mid1_0_0_4}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -17480 0 0 {name=CC1_0_0_5 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -17510 0 0 {name=p527 lab=mid1_0_0_4}
C {devices/lab_pin.sym} 1520 -17450 0 0 {name=p528 lab=mid1_0_0_5}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -17480 0 0 {name=CC1_0_0_6 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -17510 0 0 {name=p529 lab=mid1_0_0_5}
C {devices/lab_pin.sym} 1800 -17450 0 0 {name=p530 lab=mid1_0_0_6}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -17480 0 0 {name=CC1_0_0_7 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -17510 0 0 {name=p531 lab=mid1_0_0_6}
C {devices/lab_pin.sym} 2080 -17450 0 0 {name=p532 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -17670 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -18050 0 0 {name=MSW1_1_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -18080 0 0 {name=p533 lab=bank1}
C {devices/lab_pin.sym} 100 -18050 0 0 {name=p534 lab=s1}
C {devices/lab_pin.sym} 140 -18020 0 0 {name=p535 lab=cap1_1}
C {devices/lab_pin.sym} 140 -18050 0 0 {name=p536 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -18050 0 0 {name=MSW1_1_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -18020 0 0 {name=p537 lab=bank1}
C {devices/lab_pin.sym} 380 -18050 0 0 {name=p538 lab=s1bar}
C {devices/lab_pin.sym} 420 -18080 0 0 {name=p539 lab=cap1_1}
C {devices/lab_pin.sym} 420 -18050 0 0 {name=p540 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -18240 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -18620 0 0 {name=CC1_1_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -18650 0 0 {name=p541 lab=cap1_1}
C {devices/lab_pin.sym} 120 -18590 0 0 {name=p542 lab=mid1_1_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -18620 0 0 {name=CC1_1_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -18650 0 0 {name=p543 lab=mid1_1_0_0}
C {devices/lab_pin.sym} 400 -18590 0 0 {name=p544 lab=mid1_1_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -18620 0 0 {name=CC1_1_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -18650 0 0 {name=p545 lab=mid1_1_0_1}
C {devices/lab_pin.sym} 680 -18590 0 0 {name=p546 lab=mid1_1_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -18620 0 0 {name=CC1_1_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -18650 0 0 {name=p547 lab=mid1_1_0_2}
C {devices/lab_pin.sym} 960 -18590 0 0 {name=p548 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -18810 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -19190 0 0 {name=MSW1_2_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -19220 0 0 {name=p549 lab=bank1}
C {devices/lab_pin.sym} 100 -19190 0 0 {name=p550 lab=s2}
C {devices/lab_pin.sym} 140 -19160 0 0 {name=p551 lab=cap1_2}
C {devices/lab_pin.sym} 140 -19190 0 0 {name=p552 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -19190 0 0 {name=MSW1_2_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -19160 0 0 {name=p553 lab=bank1}
C {devices/lab_pin.sym} 380 -19190 0 0 {name=p554 lab=s2bar}
C {devices/lab_pin.sym} 420 -19220 0 0 {name=p555 lab=cap1_2}
C {devices/lab_pin.sym} 420 -19190 0 0 {name=p556 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -19380 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -19760 0 0 {name=CC1_2_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -19790 0 0 {name=p557 lab=cap1_2}
C {devices/lab_pin.sym} 120 -19730 0 0 {name=p558 lab=mid1_2_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -19760 0 0 {name=CC1_2_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -19790 0 0 {name=p559 lab=mid1_2_0_0}
C {devices/lab_pin.sym} 400 -19730 0 0 {name=p560 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -19950 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -20330 0 0 {name=MSW1_3_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -20360 0 0 {name=p561 lab=bank1}
C {devices/lab_pin.sym} 100 -20330 0 0 {name=p562 lab=s3}
C {devices/lab_pin.sym} 140 -20300 0 0 {name=p563 lab=cap1_3}
C {devices/lab_pin.sym} 140 -20330 0 0 {name=p564 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -20330 0 0 {name=MSW1_3_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -20300 0 0 {name=p565 lab=bank1}
C {devices/lab_pin.sym} 380 -20330 0 0 {name=p566 lab=s3bar}
C {devices/lab_pin.sym} 420 -20360 0 0 {name=p567 lab=cap1_3}
C {devices/lab_pin.sym} 420 -20330 0 0 {name=p568 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -20520 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -20900 0 0 {name=CC1_3_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -20930 0 0 {name=p569 lab=cap1_3}
C {devices/lab_pin.sym} 120 -20870 0 0 {name=p570 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -21090 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -21470 0 0 {name=MSW1_4_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -21500 0 0 {name=p571 lab=bank1}
C {devices/lab_pin.sym} 100 -21470 0 0 {name=p572 lab=s4}
C {devices/lab_pin.sym} 140 -21440 0 0 {name=p573 lab=cap1_4}
C {devices/lab_pin.sym} 140 -21470 0 0 {name=p574 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -21470 0 0 {name=MSW1_4_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -21440 0 0 {name=p575 lab=bank1}
C {devices/lab_pin.sym} 380 -21470 0 0 {name=p576 lab=s4bar}
C {devices/lab_pin.sym} 420 -21500 0 0 {name=p577 lab=cap1_4}
C {devices/lab_pin.sym} 420 -21470 0 0 {name=p578 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -21660 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -22040 0 0 {name=CC1_4_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -22070 0 0 {name=p579 lab=cap1_4}
C {devices/lab_pin.sym} 120 -22010 0 0 {name=p580 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -22040 0 0 {name=CC1_4_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -22070 0 0 {name=p581 lab=cap1_4}
C {devices/lab_pin.sym} 400 -22010 0 0 {name=p582 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -22230 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -22610 0 0 {name=MSW1_5_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -22640 0 0 {name=p583 lab=bank1}
C {devices/lab_pin.sym} 100 -22610 0 0 {name=p584 lab=s5}
C {devices/lab_pin.sym} 140 -22580 0 0 {name=p585 lab=cap1_5}
C {devices/lab_pin.sym} 140 -22610 0 0 {name=p586 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -22610 0 0 {name=MSW1_5_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -22580 0 0 {name=p587 lab=bank1}
C {devices/lab_pin.sym} 380 -22610 0 0 {name=p588 lab=s5bar}
C {devices/lab_pin.sym} 420 -22640 0 0 {name=p589 lab=cap1_5}
C {devices/lab_pin.sym} 420 -22610 0 0 {name=p590 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -22800 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -23180 0 0 {name=CC1_5_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -23210 0 0 {name=p591 lab=cap1_5}
C {devices/lab_pin.sym} 120 -23150 0 0 {name=p592 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -23180 0 0 {name=CC1_5_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -23210 0 0 {name=p593 lab=cap1_5}
C {devices/lab_pin.sym} 400 -23150 0 0 {name=p594 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -23180 0 0 {name=CC1_5_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -23210 0 0 {name=p595 lab=cap1_5}
C {devices/lab_pin.sym} 680 -23150 0 0 {name=p596 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -23180 0 0 {name=CC1_5_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -23210 0 0 {name=p597 lab=cap1_5}
C {devices/lab_pin.sym} 960 -23150 0 0 {name=p598 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -23370 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -23750 0 0 {name=MSW1_6_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -23780 0 0 {name=p599 lab=bank1}
C {devices/lab_pin.sym} 100 -23750 0 0 {name=p600 lab=s6}
C {devices/lab_pin.sym} 140 -23720 0 0 {name=p601 lab=cap1_6}
C {devices/lab_pin.sym} 140 -23750 0 0 {name=p602 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -23750 0 0 {name=MSW1_6_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -23720 0 0 {name=p603 lab=bank1}
C {devices/lab_pin.sym} 380 -23750 0 0 {name=p604 lab=s6bar}
C {devices/lab_pin.sym} 420 -23780 0 0 {name=p605 lab=cap1_6}
C {devices/lab_pin.sym} 420 -23750 0 0 {name=p606 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -23940 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -24320 0 0 {name=CC1_6_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -24350 0 0 {name=p607 lab=cap1_6}
C {devices/lab_pin.sym} 120 -24290 0 0 {name=p608 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -24320 0 0 {name=CC1_6_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -24350 0 0 {name=p609 lab=cap1_6}
C {devices/lab_pin.sym} 400 -24290 0 0 {name=p610 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -24320 0 0 {name=CC1_6_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -24350 0 0 {name=p611 lab=cap1_6}
C {devices/lab_pin.sym} 680 -24290 0 0 {name=p612 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -24320 0 0 {name=CC1_6_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -24350 0 0 {name=p613 lab=cap1_6}
C {devices/lab_pin.sym} 960 -24290 0 0 {name=p614 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -24320 0 0 {name=CC1_6_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -24350 0 0 {name=p615 lab=cap1_6}
C {devices/lab_pin.sym} 1240 -24290 0 0 {name=p616 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -24320 0 0 {name=CC1_6_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -24350 0 0 {name=p617 lab=cap1_6}
C {devices/lab_pin.sym} 1520 -24290 0 0 {name=p618 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -24320 0 0 {name=CC1_6_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -24350 0 0 {name=p619 lab=cap1_6}
C {devices/lab_pin.sym} 1800 -24290 0 0 {name=p620 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -24320 0 0 {name=CC1_6_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -24350 0 0 {name=p621 lab=cap1_6}
C {devices/lab_pin.sym} 2080 -24290 0 0 {name=p622 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -24510 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -24890 0 0 {name=MSW1_7_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -24920 0 0 {name=p623 lab=bank1}
C {devices/lab_pin.sym} 100 -24890 0 0 {name=p624 lab=s7}
C {devices/lab_pin.sym} 140 -24860 0 0 {name=p625 lab=cap1_7}
C {devices/lab_pin.sym} 140 -24890 0 0 {name=p626 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -24890 0 0 {name=MSW1_7_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -24860 0 0 {name=p627 lab=bank1}
C {devices/lab_pin.sym} 380 -24890 0 0 {name=p628 lab=s7bar}
C {devices/lab_pin.sym} 420 -24920 0 0 {name=p629 lab=cap1_7}
C {devices/lab_pin.sym} 420 -24890 0 0 {name=p630 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -25080 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -25460 0 0 {name=CC1_7_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -25490 0 0 {name=p631 lab=cap1_7}
C {devices/lab_pin.sym} 120 -25430 0 0 {name=p632 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -25460 0 0 {name=CC1_7_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -25490 0 0 {name=p633 lab=cap1_7}
C {devices/lab_pin.sym} 400 -25430 0 0 {name=p634 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -25460 0 0 {name=CC1_7_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -25490 0 0 {name=p635 lab=cap1_7}
C {devices/lab_pin.sym} 680 -25430 0 0 {name=p636 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -25460 0 0 {name=CC1_7_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -25490 0 0 {name=p637 lab=cap1_7}
C {devices/lab_pin.sym} 960 -25430 0 0 {name=p638 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -25460 0 0 {name=CC1_7_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -25490 0 0 {name=p639 lab=cap1_7}
C {devices/lab_pin.sym} 1240 -25430 0 0 {name=p640 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -25460 0 0 {name=CC1_7_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -25490 0 0 {name=p641 lab=cap1_7}
C {devices/lab_pin.sym} 1520 -25430 0 0 {name=p642 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -25460 0 0 {name=CC1_7_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -25490 0 0 {name=p643 lab=cap1_7}
C {devices/lab_pin.sym} 1800 -25430 0 0 {name=p644 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -25460 0 0 {name=CC1_7_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -25490 0 0 {name=p645 lab=cap1_7}
C {devices/lab_pin.sym} 2080 -25430 0 0 {name=p646 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -25650 0 0 {name=CC1_7_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -25680 0 0 {name=p647 lab=cap1_7}
C {devices/lab_pin.sym} 120 -25620 0 0 {name=p648 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -25650 0 0 {name=CC1_7_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -25680 0 0 {name=p649 lab=cap1_7}
C {devices/lab_pin.sym} 400 -25620 0 0 {name=p650 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -25650 0 0 {name=CC1_7_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -25680 0 0 {name=p651 lab=cap1_7}
C {devices/lab_pin.sym} 680 -25620 0 0 {name=p652 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -25650 0 0 {name=CC1_7_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -25680 0 0 {name=p653 lab=cap1_7}
C {devices/lab_pin.sym} 960 -25620 0 0 {name=p654 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -25650 0 0 {name=CC1_7_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -25680 0 0 {name=p655 lab=cap1_7}
C {devices/lab_pin.sym} 1240 -25620 0 0 {name=p656 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -25650 0 0 {name=CC1_7_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -25680 0 0 {name=p657 lab=cap1_7}
C {devices/lab_pin.sym} 1520 -25620 0 0 {name=p658 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -25650 0 0 {name=CC1_7_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -25680 0 0 {name=p659 lab=cap1_7}
C {devices/lab_pin.sym} 1800 -25620 0 0 {name=p660 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -25650 0 0 {name=CC1_7_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -25680 0 0 {name=p661 lab=cap1_7}
C {devices/lab_pin.sym} 2080 -25620 0 0 {name=p662 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -25840 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -26220 0 0 {name=MSW1_8_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -26250 0 0 {name=p663 lab=bank1}
C {devices/lab_pin.sym} 100 -26220 0 0 {name=p664 lab=s8}
C {devices/lab_pin.sym} 140 -26190 0 0 {name=p665 lab=cap1_8}
C {devices/lab_pin.sym} 140 -26220 0 0 {name=p666 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -26220 0 0 {name=MSW1_8_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -26190 0 0 {name=p667 lab=bank1}
C {devices/lab_pin.sym} 380 -26220 0 0 {name=p668 lab=s8bar}
C {devices/lab_pin.sym} 420 -26250 0 0 {name=p669 lab=cap1_8}
C {devices/lab_pin.sym} 420 -26220 0 0 {name=p670 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -26410 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -26790 0 0 {name=CC1_8_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -26820 0 0 {name=p671 lab=cap1_8}
C {devices/lab_pin.sym} 120 -26760 0 0 {name=p672 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -26790 0 0 {name=CC1_8_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -26820 0 0 {name=p673 lab=cap1_8}
C {devices/lab_pin.sym} 400 -26760 0 0 {name=p674 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -26790 0 0 {name=CC1_8_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -26820 0 0 {name=p675 lab=cap1_8}
C {devices/lab_pin.sym} 680 -26760 0 0 {name=p676 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -26790 0 0 {name=CC1_8_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -26820 0 0 {name=p677 lab=cap1_8}
C {devices/lab_pin.sym} 960 -26760 0 0 {name=p678 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -26790 0 0 {name=CC1_8_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -26820 0 0 {name=p679 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -26760 0 0 {name=p680 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -26790 0 0 {name=CC1_8_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -26820 0 0 {name=p681 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -26760 0 0 {name=p682 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -26790 0 0 {name=CC1_8_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -26820 0 0 {name=p683 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -26760 0 0 {name=p684 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -26790 0 0 {name=CC1_8_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -26820 0 0 {name=p685 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -26760 0 0 {name=p686 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -26980 0 0 {name=CC1_8_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -27010 0 0 {name=p687 lab=cap1_8}
C {devices/lab_pin.sym} 120 -26950 0 0 {name=p688 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -26980 0 0 {name=CC1_8_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -27010 0 0 {name=p689 lab=cap1_8}
C {devices/lab_pin.sym} 400 -26950 0 0 {name=p690 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -26980 0 0 {name=CC1_8_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -27010 0 0 {name=p691 lab=cap1_8}
C {devices/lab_pin.sym} 680 -26950 0 0 {name=p692 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -26980 0 0 {name=CC1_8_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -27010 0 0 {name=p693 lab=cap1_8}
C {devices/lab_pin.sym} 960 -26950 0 0 {name=p694 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -26980 0 0 {name=CC1_8_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -27010 0 0 {name=p695 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -26950 0 0 {name=p696 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -26980 0 0 {name=CC1_8_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -27010 0 0 {name=p697 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -26950 0 0 {name=p698 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -26980 0 0 {name=CC1_8_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -27010 0 0 {name=p699 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -26950 0 0 {name=p700 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -26980 0 0 {name=CC1_8_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -27010 0 0 {name=p701 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -26950 0 0 {name=p702 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -27170 0 0 {name=CC1_8_16_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -27200 0 0 {name=p703 lab=cap1_8}
C {devices/lab_pin.sym} 120 -27140 0 0 {name=p704 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -27170 0 0 {name=CC1_8_17_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -27200 0 0 {name=p705 lab=cap1_8}
C {devices/lab_pin.sym} 400 -27140 0 0 {name=p706 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -27170 0 0 {name=CC1_8_18_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -27200 0 0 {name=p707 lab=cap1_8}
C {devices/lab_pin.sym} 680 -27140 0 0 {name=p708 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -27170 0 0 {name=CC1_8_19_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -27200 0 0 {name=p709 lab=cap1_8}
C {devices/lab_pin.sym} 960 -27140 0 0 {name=p710 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -27170 0 0 {name=CC1_8_20_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -27200 0 0 {name=p711 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -27140 0 0 {name=p712 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -27170 0 0 {name=CC1_8_21_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -27200 0 0 {name=p713 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -27140 0 0 {name=p714 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -27170 0 0 {name=CC1_8_22_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -27200 0 0 {name=p715 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -27140 0 0 {name=p716 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -27170 0 0 {name=CC1_8_23_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -27200 0 0 {name=p717 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -27140 0 0 {name=p718 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -27360 0 0 {name=CC1_8_24_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -27390 0 0 {name=p719 lab=cap1_8}
C {devices/lab_pin.sym} 120 -27330 0 0 {name=p720 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -27360 0 0 {name=CC1_8_25_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -27390 0 0 {name=p721 lab=cap1_8}
C {devices/lab_pin.sym} 400 -27330 0 0 {name=p722 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -27360 0 0 {name=CC1_8_26_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -27390 0 0 {name=p723 lab=cap1_8}
C {devices/lab_pin.sym} 680 -27330 0 0 {name=p724 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -27360 0 0 {name=CC1_8_27_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -27390 0 0 {name=p725 lab=cap1_8}
C {devices/lab_pin.sym} 960 -27330 0 0 {name=p726 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -27360 0 0 {name=CC1_8_28_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -27390 0 0 {name=p727 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -27330 0 0 {name=p728 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -27360 0 0 {name=CC1_8_29_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -27390 0 0 {name=p729 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -27330 0 0 {name=p730 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -27360 0 0 {name=CC1_8_30_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -27390 0 0 {name=p731 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -27330 0 0 {name=p732 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -27360 0 0 {name=CC1_8_31_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -27390 0 0 {name=p733 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -27330 0 0 {name=p734 lab=0}
T {RING — PDK symbols; nets use named labels} 80 -27550 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -27930 0 0 {name=MINV2_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -27960 0 0 {name=p735 lab=d2}
C {devices/lab_pin.sym} 100 -27930 0 0 {name=p736 lab=n1}
C {devices/lab_pin.sym} 140 -27900 0 0 {name=p737 lab=0}
C {devices/lab_pin.sym} 140 -27930 0 0 {name=p738 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -27930 0 0 {name=MINV2_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -27900 0 0 {name=p739 lab=d2}
C {devices/lab_pin.sym} 380 -27930 0 0 {name=p740 lab=n1}
C {devices/lab_pin.sym} 420 -27960 0 0 {name=p741 lab=vdd}
C {devices/lab_pin.sym} 420 -27930 0 0 {name=p742 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -28120 0 0 0.35 0.35 {}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 120 -28500 0 0 {name=RRDELAY2 model=res_xhigh_po_1p41 L=330 mult=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -28530 0 0 {name=p743 lab=d2}
C {devices/lab_pin.sym} 120 -28470 0 0 {name=p744 lab=n2}
C {devices/lab_pin.sym} 100 -28500 0 0 {name=p745 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -28500 0 0 {name=CCBASE2 model=cap_mim_m3_2 W=15.7 L=15.7 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -28530 0 0 {name=p746 lab=n2}
C {devices/lab_pin.sym} 400 -28470 0 0 {name=p747 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -28690 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -29070 0 0 {name=MMAIN2_N L=0.15 W=8 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -29100 0 0 {name=p748 lab=n2}
C {devices/lab_pin.sym} 100 -29070 0 0 {name=p749 lab=smain}
C {devices/lab_pin.sym} 140 -29040 0 0 {name=p750 lab=bank2}
C {devices/lab_pin.sym} 140 -29070 0 0 {name=p751 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -29070 0 0 {name=MMAIN2_P L=0.15 W=16 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -29040 0 0 {name=p752 lab=n2}
C {devices/lab_pin.sym} 380 -29070 0 0 {name=p753 lab=smainbar}
C {devices/lab_pin.sym} 420 -29100 0 0 {name=p754 lab=bank2}
C {devices/lab_pin.sym} 420 -29070 0 0 {name=p755 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -29260 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -29640 0 0 {name=MSW2_0_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -29670 0 0 {name=p756 lab=bank2}
C {devices/lab_pin.sym} 100 -29640 0 0 {name=p757 lab=s0}
C {devices/lab_pin.sym} 140 -29610 0 0 {name=p758 lab=cap2_0}
C {devices/lab_pin.sym} 140 -29640 0 0 {name=p759 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -29640 0 0 {name=MSW2_0_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -29610 0 0 {name=p760 lab=bank2}
C {devices/lab_pin.sym} 380 -29640 0 0 {name=p761 lab=s0bar}
C {devices/lab_pin.sym} 420 -29670 0 0 {name=p762 lab=cap2_0}
C {devices/lab_pin.sym} 420 -29640 0 0 {name=p763 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -29830 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -30210 0 0 {name=CC2_0_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -30240 0 0 {name=p764 lab=cap2_0}
C {devices/lab_pin.sym} 120 -30180 0 0 {name=p765 lab=mid2_0_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -30210 0 0 {name=CC2_0_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -30240 0 0 {name=p766 lab=mid2_0_0_0}
C {devices/lab_pin.sym} 400 -30180 0 0 {name=p767 lab=mid2_0_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -30210 0 0 {name=CC2_0_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -30240 0 0 {name=p768 lab=mid2_0_0_1}
C {devices/lab_pin.sym} 680 -30180 0 0 {name=p769 lab=mid2_0_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -30210 0 0 {name=CC2_0_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -30240 0 0 {name=p770 lab=mid2_0_0_2}
C {devices/lab_pin.sym} 960 -30180 0 0 {name=p771 lab=mid2_0_0_3}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -30210 0 0 {name=CC2_0_0_4 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -30240 0 0 {name=p772 lab=mid2_0_0_3}
C {devices/lab_pin.sym} 1240 -30180 0 0 {name=p773 lab=mid2_0_0_4}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -30210 0 0 {name=CC2_0_0_5 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -30240 0 0 {name=p774 lab=mid2_0_0_4}
C {devices/lab_pin.sym} 1520 -30180 0 0 {name=p775 lab=mid2_0_0_5}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -30210 0 0 {name=CC2_0_0_6 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -30240 0 0 {name=p776 lab=mid2_0_0_5}
C {devices/lab_pin.sym} 1800 -30180 0 0 {name=p777 lab=mid2_0_0_6}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -30210 0 0 {name=CC2_0_0_7 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -30240 0 0 {name=p778 lab=mid2_0_0_6}
C {devices/lab_pin.sym} 2080 -30180 0 0 {name=p779 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -30400 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -30780 0 0 {name=MSW2_1_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -30810 0 0 {name=p780 lab=bank2}
C {devices/lab_pin.sym} 100 -30780 0 0 {name=p781 lab=s1}
C {devices/lab_pin.sym} 140 -30750 0 0 {name=p782 lab=cap2_1}
C {devices/lab_pin.sym} 140 -30780 0 0 {name=p783 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -30780 0 0 {name=MSW2_1_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -30750 0 0 {name=p784 lab=bank2}
C {devices/lab_pin.sym} 380 -30780 0 0 {name=p785 lab=s1bar}
C {devices/lab_pin.sym} 420 -30810 0 0 {name=p786 lab=cap2_1}
C {devices/lab_pin.sym} 420 -30780 0 0 {name=p787 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -30970 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -31350 0 0 {name=CC2_1_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -31380 0 0 {name=p788 lab=cap2_1}
C {devices/lab_pin.sym} 120 -31320 0 0 {name=p789 lab=mid2_1_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -31350 0 0 {name=CC2_1_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -31380 0 0 {name=p790 lab=mid2_1_0_0}
C {devices/lab_pin.sym} 400 -31320 0 0 {name=p791 lab=mid2_1_0_1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -31350 0 0 {name=CC2_1_0_2 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -31380 0 0 {name=p792 lab=mid2_1_0_1}
C {devices/lab_pin.sym} 680 -31320 0 0 {name=p793 lab=mid2_1_0_2}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -31350 0 0 {name=CC2_1_0_3 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -31380 0 0 {name=p794 lab=mid2_1_0_2}
C {devices/lab_pin.sym} 960 -31320 0 0 {name=p795 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -31540 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -31920 0 0 {name=MSW2_2_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -31950 0 0 {name=p796 lab=bank2}
C {devices/lab_pin.sym} 100 -31920 0 0 {name=p797 lab=s2}
C {devices/lab_pin.sym} 140 -31890 0 0 {name=p798 lab=cap2_2}
C {devices/lab_pin.sym} 140 -31920 0 0 {name=p799 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -31920 0 0 {name=MSW2_2_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -31890 0 0 {name=p800 lab=bank2}
C {devices/lab_pin.sym} 380 -31920 0 0 {name=p801 lab=s2bar}
C {devices/lab_pin.sym} 420 -31950 0 0 {name=p802 lab=cap2_2}
C {devices/lab_pin.sym} 420 -31920 0 0 {name=p803 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -32110 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -32490 0 0 {name=CC2_2_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -32520 0 0 {name=p804 lab=cap2_2}
C {devices/lab_pin.sym} 120 -32460 0 0 {name=p805 lab=mid2_2_0_0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -32490 0 0 {name=CC2_2_0_1 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -32520 0 0 {name=p806 lab=mid2_2_0_0}
C {devices/lab_pin.sym} 400 -32460 0 0 {name=p807 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -32680 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -33060 0 0 {name=MSW2_3_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -33090 0 0 {name=p808 lab=bank2}
C {devices/lab_pin.sym} 100 -33060 0 0 {name=p809 lab=s3}
C {devices/lab_pin.sym} 140 -33030 0 0 {name=p810 lab=cap2_3}
C {devices/lab_pin.sym} 140 -33060 0 0 {name=p811 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -33060 0 0 {name=MSW2_3_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -33030 0 0 {name=p812 lab=bank2}
C {devices/lab_pin.sym} 380 -33060 0 0 {name=p813 lab=s3bar}
C {devices/lab_pin.sym} 420 -33090 0 0 {name=p814 lab=cap2_3}
C {devices/lab_pin.sym} 420 -33060 0 0 {name=p815 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -33250 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -33630 0 0 {name=CC2_3_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -33660 0 0 {name=p816 lab=cap2_3}
C {devices/lab_pin.sym} 120 -33600 0 0 {name=p817 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -33820 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -34200 0 0 {name=MSW2_4_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -34230 0 0 {name=p818 lab=bank2}
C {devices/lab_pin.sym} 100 -34200 0 0 {name=p819 lab=s4}
C {devices/lab_pin.sym} 140 -34170 0 0 {name=p820 lab=cap2_4}
C {devices/lab_pin.sym} 140 -34200 0 0 {name=p821 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -34200 0 0 {name=MSW2_4_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -34170 0 0 {name=p822 lab=bank2}
C {devices/lab_pin.sym} 380 -34200 0 0 {name=p823 lab=s4bar}
C {devices/lab_pin.sym} 420 -34230 0 0 {name=p824 lab=cap2_4}
C {devices/lab_pin.sym} 420 -34200 0 0 {name=p825 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -34390 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -34770 0 0 {name=CC2_4_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -34800 0 0 {name=p826 lab=cap2_4}
C {devices/lab_pin.sym} 120 -34740 0 0 {name=p827 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -34770 0 0 {name=CC2_4_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -34800 0 0 {name=p828 lab=cap2_4}
C {devices/lab_pin.sym} 400 -34740 0 0 {name=p829 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -34960 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -35340 0 0 {name=MSW2_5_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -35370 0 0 {name=p830 lab=bank2}
C {devices/lab_pin.sym} 100 -35340 0 0 {name=p831 lab=s5}
C {devices/lab_pin.sym} 140 -35310 0 0 {name=p832 lab=cap2_5}
C {devices/lab_pin.sym} 140 -35340 0 0 {name=p833 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -35340 0 0 {name=MSW2_5_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -35310 0 0 {name=p834 lab=bank2}
C {devices/lab_pin.sym} 380 -35340 0 0 {name=p835 lab=s5bar}
C {devices/lab_pin.sym} 420 -35370 0 0 {name=p836 lab=cap2_5}
C {devices/lab_pin.sym} 420 -35340 0 0 {name=p837 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -35530 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -35910 0 0 {name=CC2_5_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -35940 0 0 {name=p838 lab=cap2_5}
C {devices/lab_pin.sym} 120 -35880 0 0 {name=p839 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -35910 0 0 {name=CC2_5_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -35940 0 0 {name=p840 lab=cap2_5}
C {devices/lab_pin.sym} 400 -35880 0 0 {name=p841 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -35910 0 0 {name=CC2_5_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -35940 0 0 {name=p842 lab=cap2_5}
C {devices/lab_pin.sym} 680 -35880 0 0 {name=p843 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -35910 0 0 {name=CC2_5_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -35940 0 0 {name=p844 lab=cap2_5}
C {devices/lab_pin.sym} 960 -35880 0 0 {name=p845 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -36100 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -36480 0 0 {name=MSW2_6_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -36510 0 0 {name=p846 lab=bank2}
C {devices/lab_pin.sym} 100 -36480 0 0 {name=p847 lab=s6}
C {devices/lab_pin.sym} 140 -36450 0 0 {name=p848 lab=cap2_6}
C {devices/lab_pin.sym} 140 -36480 0 0 {name=p849 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -36480 0 0 {name=MSW2_6_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -36450 0 0 {name=p850 lab=bank2}
C {devices/lab_pin.sym} 380 -36480 0 0 {name=p851 lab=s6bar}
C {devices/lab_pin.sym} 420 -36510 0 0 {name=p852 lab=cap2_6}
C {devices/lab_pin.sym} 420 -36480 0 0 {name=p853 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -36670 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -37050 0 0 {name=CC2_6_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -37080 0 0 {name=p854 lab=cap2_6}
C {devices/lab_pin.sym} 120 -37020 0 0 {name=p855 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -37050 0 0 {name=CC2_6_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -37080 0 0 {name=p856 lab=cap2_6}
C {devices/lab_pin.sym} 400 -37020 0 0 {name=p857 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -37050 0 0 {name=CC2_6_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -37080 0 0 {name=p858 lab=cap2_6}
C {devices/lab_pin.sym} 680 -37020 0 0 {name=p859 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -37050 0 0 {name=CC2_6_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -37080 0 0 {name=p860 lab=cap2_6}
C {devices/lab_pin.sym} 960 -37020 0 0 {name=p861 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -37050 0 0 {name=CC2_6_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -37080 0 0 {name=p862 lab=cap2_6}
C {devices/lab_pin.sym} 1240 -37020 0 0 {name=p863 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -37050 0 0 {name=CC2_6_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -37080 0 0 {name=p864 lab=cap2_6}
C {devices/lab_pin.sym} 1520 -37020 0 0 {name=p865 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -37050 0 0 {name=CC2_6_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -37080 0 0 {name=p866 lab=cap2_6}
C {devices/lab_pin.sym} 1800 -37020 0 0 {name=p867 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -37050 0 0 {name=CC2_6_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -37080 0 0 {name=p868 lab=cap2_6}
C {devices/lab_pin.sym} 2080 -37020 0 0 {name=p869 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -37240 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -37620 0 0 {name=MSW2_7_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -37650 0 0 {name=p870 lab=bank2}
C {devices/lab_pin.sym} 100 -37620 0 0 {name=p871 lab=s7}
C {devices/lab_pin.sym} 140 -37590 0 0 {name=p872 lab=cap2_7}
C {devices/lab_pin.sym} 140 -37620 0 0 {name=p873 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -37620 0 0 {name=MSW2_7_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -37590 0 0 {name=p874 lab=bank2}
C {devices/lab_pin.sym} 380 -37620 0 0 {name=p875 lab=s7bar}
C {devices/lab_pin.sym} 420 -37650 0 0 {name=p876 lab=cap2_7}
C {devices/lab_pin.sym} 420 -37620 0 0 {name=p877 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -37810 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -38190 0 0 {name=CC2_7_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -38220 0 0 {name=p878 lab=cap2_7}
C {devices/lab_pin.sym} 120 -38160 0 0 {name=p879 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -38190 0 0 {name=CC2_7_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -38220 0 0 {name=p880 lab=cap2_7}
C {devices/lab_pin.sym} 400 -38160 0 0 {name=p881 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -38190 0 0 {name=CC2_7_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -38220 0 0 {name=p882 lab=cap2_7}
C {devices/lab_pin.sym} 680 -38160 0 0 {name=p883 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -38190 0 0 {name=CC2_7_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -38220 0 0 {name=p884 lab=cap2_7}
C {devices/lab_pin.sym} 960 -38160 0 0 {name=p885 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -38190 0 0 {name=CC2_7_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -38220 0 0 {name=p886 lab=cap2_7}
C {devices/lab_pin.sym} 1240 -38160 0 0 {name=p887 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -38190 0 0 {name=CC2_7_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -38220 0 0 {name=p888 lab=cap2_7}
C {devices/lab_pin.sym} 1520 -38160 0 0 {name=p889 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -38190 0 0 {name=CC2_7_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -38220 0 0 {name=p890 lab=cap2_7}
C {devices/lab_pin.sym} 1800 -38160 0 0 {name=p891 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -38190 0 0 {name=CC2_7_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -38220 0 0 {name=p892 lab=cap2_7}
C {devices/lab_pin.sym} 2080 -38160 0 0 {name=p893 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -38380 0 0 {name=CC2_7_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -38410 0 0 {name=p894 lab=cap2_7}
C {devices/lab_pin.sym} 120 -38350 0 0 {name=p895 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -38380 0 0 {name=CC2_7_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -38410 0 0 {name=p896 lab=cap2_7}
C {devices/lab_pin.sym} 400 -38350 0 0 {name=p897 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -38380 0 0 {name=CC2_7_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -38410 0 0 {name=p898 lab=cap2_7}
C {devices/lab_pin.sym} 680 -38350 0 0 {name=p899 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -38380 0 0 {name=CC2_7_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -38410 0 0 {name=p900 lab=cap2_7}
C {devices/lab_pin.sym} 960 -38350 0 0 {name=p901 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -38380 0 0 {name=CC2_7_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -38410 0 0 {name=p902 lab=cap2_7}
C {devices/lab_pin.sym} 1240 -38350 0 0 {name=p903 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -38380 0 0 {name=CC2_7_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -38410 0 0 {name=p904 lab=cap2_7}
C {devices/lab_pin.sym} 1520 -38350 0 0 {name=p905 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -38380 0 0 {name=CC2_7_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -38410 0 0 {name=p906 lab=cap2_7}
C {devices/lab_pin.sym} 1800 -38350 0 0 {name=p907 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -38380 0 0 {name=CC2_7_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -38410 0 0 {name=p908 lab=cap2_7}
C {devices/lab_pin.sym} 2080 -38350 0 0 {name=p909 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -38570 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -38950 0 0 {name=MSW2_8_N L=0.15 W=1 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -38980 0 0 {name=p910 lab=bank2}
C {devices/lab_pin.sym} 100 -38950 0 0 {name=p911 lab=s8}
C {devices/lab_pin.sym} 140 -38920 0 0 {name=p912 lab=cap2_8}
C {devices/lab_pin.sym} 140 -38950 0 0 {name=p913 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -38950 0 0 {name=MSW2_8_P L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -38920 0 0 {name=p914 lab=bank2}
C {devices/lab_pin.sym} 380 -38950 0 0 {name=p915 lab=s8bar}
C {devices/lab_pin.sym} 420 -38980 0 0 {name=p916 lab=cap2_8}
C {devices/lab_pin.sym} 420 -38950 0 0 {name=p917 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -39140 0 0 0.35 0.35 {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -39520 0 0 {name=CC2_8_0_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -39550 0 0 {name=p918 lab=cap2_8}
C {devices/lab_pin.sym} 120 -39490 0 0 {name=p919 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -39520 0 0 {name=CC2_8_1_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -39550 0 0 {name=p920 lab=cap2_8}
C {devices/lab_pin.sym} 400 -39490 0 0 {name=p921 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -39520 0 0 {name=CC2_8_2_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -39550 0 0 {name=p922 lab=cap2_8}
C {devices/lab_pin.sym} 680 -39490 0 0 {name=p923 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -39520 0 0 {name=CC2_8_3_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -39550 0 0 {name=p924 lab=cap2_8}
C {devices/lab_pin.sym} 960 -39490 0 0 {name=p925 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -39520 0 0 {name=CC2_8_4_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -39550 0 0 {name=p926 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -39490 0 0 {name=p927 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -39520 0 0 {name=CC2_8_5_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -39550 0 0 {name=p928 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -39490 0 0 {name=p929 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -39520 0 0 {name=CC2_8_6_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -39550 0 0 {name=p930 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -39490 0 0 {name=p931 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -39520 0 0 {name=CC2_8_7_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -39550 0 0 {name=p932 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -39490 0 0 {name=p933 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -39710 0 0 {name=CC2_8_8_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -39740 0 0 {name=p934 lab=cap2_8}
C {devices/lab_pin.sym} 120 -39680 0 0 {name=p935 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -39710 0 0 {name=CC2_8_9_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -39740 0 0 {name=p936 lab=cap2_8}
C {devices/lab_pin.sym} 400 -39680 0 0 {name=p937 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -39710 0 0 {name=CC2_8_10_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -39740 0 0 {name=p938 lab=cap2_8}
C {devices/lab_pin.sym} 680 -39680 0 0 {name=p939 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -39710 0 0 {name=CC2_8_11_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -39740 0 0 {name=p940 lab=cap2_8}
C {devices/lab_pin.sym} 960 -39680 0 0 {name=p941 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -39710 0 0 {name=CC2_8_12_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -39740 0 0 {name=p942 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -39680 0 0 {name=p943 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -39710 0 0 {name=CC2_8_13_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -39740 0 0 {name=p944 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -39680 0 0 {name=p945 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -39710 0 0 {name=CC2_8_14_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -39740 0 0 {name=p946 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -39680 0 0 {name=p947 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -39710 0 0 {name=CC2_8_15_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -39740 0 0 {name=p948 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -39680 0 0 {name=p949 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -39900 0 0 {name=CC2_8_16_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -39930 0 0 {name=p950 lab=cap2_8}
C {devices/lab_pin.sym} 120 -39870 0 0 {name=p951 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -39900 0 0 {name=CC2_8_17_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -39930 0 0 {name=p952 lab=cap2_8}
C {devices/lab_pin.sym} 400 -39870 0 0 {name=p953 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -39900 0 0 {name=CC2_8_18_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -39930 0 0 {name=p954 lab=cap2_8}
C {devices/lab_pin.sym} 680 -39870 0 0 {name=p955 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -39900 0 0 {name=CC2_8_19_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -39930 0 0 {name=p956 lab=cap2_8}
C {devices/lab_pin.sym} 960 -39870 0 0 {name=p957 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -39900 0 0 {name=CC2_8_20_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -39930 0 0 {name=p958 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -39870 0 0 {name=p959 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -39900 0 0 {name=CC2_8_21_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -39930 0 0 {name=p960 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -39870 0 0 {name=p961 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -39900 0 0 {name=CC2_8_22_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -39930 0 0 {name=p962 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -39870 0 0 {name=p963 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -39900 0 0 {name=CC2_8_23_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -39930 0 0 {name=p964 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -39870 0 0 {name=p965 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 120 -40090 0 0 {name=CC2_8_24_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -40120 0 0 {name=p966 lab=cap2_8}
C {devices/lab_pin.sym} 120 -40060 0 0 {name=p967 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 400 -40090 0 0 {name=CC2_8_25_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -40120 0 0 {name=p968 lab=cap2_8}
C {devices/lab_pin.sym} 400 -40060 0 0 {name=p969 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 680 -40090 0 0 {name=CC2_8_26_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -40120 0 0 {name=p970 lab=cap2_8}
C {devices/lab_pin.sym} 680 -40060 0 0 {name=p971 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 960 -40090 0 0 {name=CC2_8_27_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -40120 0 0 {name=p972 lab=cap2_8}
C {devices/lab_pin.sym} 960 -40060 0 0 {name=p973 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1240 -40090 0 0 {name=CC2_8_28_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -40120 0 0 {name=p974 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -40060 0 0 {name=p975 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1520 -40090 0 0 {name=CC2_8_29_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -40120 0 0 {name=p976 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -40060 0 0 {name=p977 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1800 -40090 0 0 {name=CC2_8_30_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -40120 0 0 {name=p978 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -40060 0 0 {name=p979 lab=0}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2080 -40090 0 0 {name=CC2_8_31_0 model=cap_mim_m3_2 W=4.5 L=4.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -40120 0 0 {name=p980 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -40060 0 0 {name=p981 lab=0}
T {BUFFER — PDK symbols; nets use named labels} 80 -40280 0 0 0.35 0.35 {}
C {sky130_fd_pr/nfet_01v8.sym} 120 -40660 0 0 {name=MBUF0_N L=0.15 W=2 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 140 -40690 0 0 {name=p982 lab=buf}
C {devices/lab_pin.sym} 100 -40660 0 0 {name=p983 lab=d2}
C {devices/lab_pin.sym} 140 -40630 0 0 {name=p984 lab=0}
C {devices/lab_pin.sym} 140 -40660 0 0 {name=p985 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 400 -40660 0 0 {name=MBUF0_P L=0.15 W=4 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 420 -40630 0 0 {name=p986 lab=buf}
C {devices/lab_pin.sym} 380 -40660 0 0 {name=p987 lab=d2}
C {devices/lab_pin.sym} 420 -40690 0 0 {name=p988 lab=vdd}
C {devices/lab_pin.sym} 420 -40660 0 0 {name=p989 lab=vdd}
C {sky130_fd_pr/nfet_01v8.sym} 680 -40660 0 0 {name=MBUF1_N L=0.15 W=8 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 700 -40690 0 0 {name=p990 lab=clk}
C {devices/lab_pin.sym} 660 -40660 0 0 {name=p991 lab=buf}
C {devices/lab_pin.sym} 700 -40630 0 0 {name=p992 lab=0}
C {devices/lab_pin.sym} 700 -40660 0 0 {name=p993 lab=0}
C {sky130_fd_pr/pfet_01v8.sym} 960 -40660 0 0 {name=MBUF1_P L=0.15 W=16 nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_01v8 spiceprefix=X}
C {devices/lab_pin.sym} 980 -40630 0 0 {name=p994 lab=clk}
C {devices/lab_pin.sym} 940 -40660 0 0 {name=p995 lab=buf}
C {devices/lab_pin.sym} 980 -40690 0 0 {name=p996 lab=vdd}
C {devices/lab_pin.sym} 980 -40660 0 0 {name=p997 lab=vdd}
