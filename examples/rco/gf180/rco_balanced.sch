v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {CONTROL — PDK symbols; nets use named labels} 80 -190 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -570 0 0 {name=MLB0_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -600 0 0 {name=p1 lab=b0bar}
C {devices/lab_pin.sym} 100 -570 0 0 {name=p2 lab=b0}
C {devices/lab_pin.sym} 140 -540 0 0 {name=p3 lab=0}
C {devices/lab_pin.sym} 140 -570 0 0 {name=p4 lab=0}
C {symbols/pfet_03v3.sym} 400 -570 0 0 {name=MLB0_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -540 0 0 {name=p5 lab=b0bar}
C {devices/lab_pin.sym} 380 -570 0 0 {name=p6 lab=b0}
C {devices/lab_pin.sym} 420 -600 0 0 {name=p7 lab=vctrl}
C {devices/lab_pin.sym} 420 -570 0 0 {name=p8 lab=vctrl}
C {symbols/nfet_03v3.sym} 680 -570 0 0 {name=MLS0_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -600 0 0 {name=p9 lab=s0bar}
C {devices/lab_pin.sym} 660 -570 0 0 {name=p10 lab=b0}
C {devices/lab_pin.sym} 700 -540 0 0 {name=p11 lab=0}
C {devices/lab_pin.sym} 700 -570 0 0 {name=p12 lab=0}
C {symbols/nfet_03v3.sym} 960 -570 0 0 {name=MLS0_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -600 0 0 {name=p13 lab=s0}
C {devices/lab_pin.sym} 940 -570 0 0 {name=p14 lab=b0bar}
C {devices/lab_pin.sym} 980 -540 0 0 {name=p15 lab=0}
C {devices/lab_pin.sym} 980 -570 0 0 {name=p16 lab=0}
C {symbols/pfet_03v3.sym} 1240 -570 0 0 {name=MLS0_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -540 0 0 {name=p17 lab=s0bar}
C {devices/lab_pin.sym} 1220 -570 0 0 {name=p18 lab=s0}
C {devices/lab_pin.sym} 1260 -600 0 0 {name=p19 lab=vdd}
C {devices/lab_pin.sym} 1260 -570 0 0 {name=p20 lab=vdd}
C {symbols/pfet_03v3.sym} 1520 -570 0 0 {name=MLS0_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -540 0 0 {name=p21 lab=s0}
C {devices/lab_pin.sym} 1500 -570 0 0 {name=p22 lab=s0bar}
C {devices/lab_pin.sym} 1540 -600 0 0 {name=p23 lab=vdd}
C {devices/lab_pin.sym} 1540 -570 0 0 {name=p24 lab=vdd}
C {symbols/nfet_03v3.sym} 1800 -570 0 0 {name=MLB1_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -600 0 0 {name=p25 lab=b1bar}
C {devices/lab_pin.sym} 1780 -570 0 0 {name=p26 lab=b1}
C {devices/lab_pin.sym} 1820 -540 0 0 {name=p27 lab=0}
C {devices/lab_pin.sym} 1820 -570 0 0 {name=p28 lab=0}
C {symbols/pfet_03v3.sym} 2080 -570 0 0 {name=MLB1_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -540 0 0 {name=p29 lab=b1bar}
C {devices/lab_pin.sym} 2060 -570 0 0 {name=p30 lab=b1}
C {devices/lab_pin.sym} 2100 -600 0 0 {name=p31 lab=vctrl}
C {devices/lab_pin.sym} 2100 -570 0 0 {name=p32 lab=vctrl}
C {symbols/nfet_03v3.sym} 120 -760 0 0 {name=MLS1_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -790 0 0 {name=p33 lab=s1bar}
C {devices/lab_pin.sym} 100 -760 0 0 {name=p34 lab=b1}
C {devices/lab_pin.sym} 140 -730 0 0 {name=p35 lab=0}
C {devices/lab_pin.sym} 140 -760 0 0 {name=p36 lab=0}
C {symbols/nfet_03v3.sym} 400 -760 0 0 {name=MLS1_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -790 0 0 {name=p37 lab=s1}
C {devices/lab_pin.sym} 380 -760 0 0 {name=p38 lab=b1bar}
C {devices/lab_pin.sym} 420 -730 0 0 {name=p39 lab=0}
C {devices/lab_pin.sym} 420 -760 0 0 {name=p40 lab=0}
C {symbols/pfet_03v3.sym} 680 -760 0 0 {name=MLS1_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -730 0 0 {name=p41 lab=s1bar}
C {devices/lab_pin.sym} 660 -760 0 0 {name=p42 lab=s1}
C {devices/lab_pin.sym} 700 -790 0 0 {name=p43 lab=vdd}
C {devices/lab_pin.sym} 700 -760 0 0 {name=p44 lab=vdd}
C {symbols/pfet_03v3.sym} 960 -760 0 0 {name=MLS1_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -730 0 0 {name=p45 lab=s1}
C {devices/lab_pin.sym} 940 -760 0 0 {name=p46 lab=s1bar}
C {devices/lab_pin.sym} 980 -790 0 0 {name=p47 lab=vdd}
C {devices/lab_pin.sym} 980 -760 0 0 {name=p48 lab=vdd}
C {symbols/nfet_03v3.sym} 1240 -760 0 0 {name=MLB2_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -790 0 0 {name=p49 lab=b2bar}
C {devices/lab_pin.sym} 1220 -760 0 0 {name=p50 lab=b2}
C {devices/lab_pin.sym} 1260 -730 0 0 {name=p51 lab=0}
C {devices/lab_pin.sym} 1260 -760 0 0 {name=p52 lab=0}
C {symbols/pfet_03v3.sym} 1520 -760 0 0 {name=MLB2_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -730 0 0 {name=p53 lab=b2bar}
C {devices/lab_pin.sym} 1500 -760 0 0 {name=p54 lab=b2}
C {devices/lab_pin.sym} 1540 -790 0 0 {name=p55 lab=vctrl}
C {devices/lab_pin.sym} 1540 -760 0 0 {name=p56 lab=vctrl}
C {symbols/nfet_03v3.sym} 1800 -760 0 0 {name=MLS2_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -790 0 0 {name=p57 lab=s2bar}
C {devices/lab_pin.sym} 1780 -760 0 0 {name=p58 lab=b2}
C {devices/lab_pin.sym} 1820 -730 0 0 {name=p59 lab=0}
C {devices/lab_pin.sym} 1820 -760 0 0 {name=p60 lab=0}
C {symbols/nfet_03v3.sym} 2080 -760 0 0 {name=MLS2_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -790 0 0 {name=p61 lab=s2}
C {devices/lab_pin.sym} 2060 -760 0 0 {name=p62 lab=b2bar}
C {devices/lab_pin.sym} 2100 -730 0 0 {name=p63 lab=0}
C {devices/lab_pin.sym} 2100 -760 0 0 {name=p64 lab=0}
C {symbols/pfet_03v3.sym} 120 -950 0 0 {name=MLS2_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -920 0 0 {name=p65 lab=s2bar}
C {devices/lab_pin.sym} 100 -950 0 0 {name=p66 lab=s2}
C {devices/lab_pin.sym} 140 -980 0 0 {name=p67 lab=vdd}
C {devices/lab_pin.sym} 140 -950 0 0 {name=p68 lab=vdd}
C {symbols/pfet_03v3.sym} 400 -950 0 0 {name=MLS2_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -920 0 0 {name=p69 lab=s2}
C {devices/lab_pin.sym} 380 -950 0 0 {name=p70 lab=s2bar}
C {devices/lab_pin.sym} 420 -980 0 0 {name=p71 lab=vdd}
C {devices/lab_pin.sym} 420 -950 0 0 {name=p72 lab=vdd}
C {symbols/nfet_03v3.sym} 680 -950 0 0 {name=MLB3_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -980 0 0 {name=p73 lab=b3bar}
C {devices/lab_pin.sym} 660 -950 0 0 {name=p74 lab=b3}
C {devices/lab_pin.sym} 700 -920 0 0 {name=p75 lab=0}
C {devices/lab_pin.sym} 700 -950 0 0 {name=p76 lab=0}
C {symbols/pfet_03v3.sym} 960 -950 0 0 {name=MLB3_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -920 0 0 {name=p77 lab=b3bar}
C {devices/lab_pin.sym} 940 -950 0 0 {name=p78 lab=b3}
C {devices/lab_pin.sym} 980 -980 0 0 {name=p79 lab=vctrl}
C {devices/lab_pin.sym} 980 -950 0 0 {name=p80 lab=vctrl}
C {symbols/nfet_03v3.sym} 1240 -950 0 0 {name=MLS3_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -980 0 0 {name=p81 lab=s3bar}
C {devices/lab_pin.sym} 1220 -950 0 0 {name=p82 lab=b3}
C {devices/lab_pin.sym} 1260 -920 0 0 {name=p83 lab=0}
C {devices/lab_pin.sym} 1260 -950 0 0 {name=p84 lab=0}
C {symbols/nfet_03v3.sym} 1520 -950 0 0 {name=MLS3_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -980 0 0 {name=p85 lab=s3}
C {devices/lab_pin.sym} 1500 -950 0 0 {name=p86 lab=b3bar}
C {devices/lab_pin.sym} 1540 -920 0 0 {name=p87 lab=0}
C {devices/lab_pin.sym} 1540 -950 0 0 {name=p88 lab=0}
C {symbols/pfet_03v3.sym} 1800 -950 0 0 {name=MLS3_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -920 0 0 {name=p89 lab=s3bar}
C {devices/lab_pin.sym} 1780 -950 0 0 {name=p90 lab=s3}
C {devices/lab_pin.sym} 1820 -980 0 0 {name=p91 lab=vdd}
C {devices/lab_pin.sym} 1820 -950 0 0 {name=p92 lab=vdd}
C {symbols/pfet_03v3.sym} 2080 -950 0 0 {name=MLS3_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -920 0 0 {name=p93 lab=s3}
C {devices/lab_pin.sym} 2060 -950 0 0 {name=p94 lab=s3bar}
C {devices/lab_pin.sym} 2100 -980 0 0 {name=p95 lab=vdd}
C {devices/lab_pin.sym} 2100 -950 0 0 {name=p96 lab=vdd}
C {symbols/nfet_03v3.sym} 120 -1140 0 0 {name=MLB4_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1170 0 0 {name=p97 lab=b4bar}
C {devices/lab_pin.sym} 100 -1140 0 0 {name=p98 lab=b4}
C {devices/lab_pin.sym} 140 -1110 0 0 {name=p99 lab=0}
C {devices/lab_pin.sym} 140 -1140 0 0 {name=p100 lab=0}
C {symbols/pfet_03v3.sym} 400 -1140 0 0 {name=MLB4_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1110 0 0 {name=p101 lab=b4bar}
C {devices/lab_pin.sym} 380 -1140 0 0 {name=p102 lab=b4}
C {devices/lab_pin.sym} 420 -1170 0 0 {name=p103 lab=vctrl}
C {devices/lab_pin.sym} 420 -1140 0 0 {name=p104 lab=vctrl}
C {symbols/nfet_03v3.sym} 680 -1140 0 0 {name=MLS4_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1170 0 0 {name=p105 lab=s4bar}
C {devices/lab_pin.sym} 660 -1140 0 0 {name=p106 lab=b4}
C {devices/lab_pin.sym} 700 -1110 0 0 {name=p107 lab=0}
C {devices/lab_pin.sym} 700 -1140 0 0 {name=p108 lab=0}
C {symbols/nfet_03v3.sym} 960 -1140 0 0 {name=MLS4_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1170 0 0 {name=p109 lab=s4}
C {devices/lab_pin.sym} 940 -1140 0 0 {name=p110 lab=b4bar}
C {devices/lab_pin.sym} 980 -1110 0 0 {name=p111 lab=0}
C {devices/lab_pin.sym} 980 -1140 0 0 {name=p112 lab=0}
C {symbols/pfet_03v3.sym} 1240 -1140 0 0 {name=MLS4_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1110 0 0 {name=p113 lab=s4bar}
C {devices/lab_pin.sym} 1220 -1140 0 0 {name=p114 lab=s4}
C {devices/lab_pin.sym} 1260 -1170 0 0 {name=p115 lab=vdd}
C {devices/lab_pin.sym} 1260 -1140 0 0 {name=p116 lab=vdd}
C {symbols/pfet_03v3.sym} 1520 -1140 0 0 {name=MLS4_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1110 0 0 {name=p117 lab=s4}
C {devices/lab_pin.sym} 1500 -1140 0 0 {name=p118 lab=s4bar}
C {devices/lab_pin.sym} 1540 -1170 0 0 {name=p119 lab=vdd}
C {devices/lab_pin.sym} 1540 -1140 0 0 {name=p120 lab=vdd}
C {symbols/nfet_03v3.sym} 1800 -1140 0 0 {name=MLB5_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1170 0 0 {name=p121 lab=b5bar}
C {devices/lab_pin.sym} 1780 -1140 0 0 {name=p122 lab=b5}
C {devices/lab_pin.sym} 1820 -1110 0 0 {name=p123 lab=0}
C {devices/lab_pin.sym} 1820 -1140 0 0 {name=p124 lab=0}
C {symbols/pfet_03v3.sym} 2080 -1140 0 0 {name=MLB5_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1110 0 0 {name=p125 lab=b5bar}
C {devices/lab_pin.sym} 2060 -1140 0 0 {name=p126 lab=b5}
C {devices/lab_pin.sym} 2100 -1170 0 0 {name=p127 lab=vctrl}
C {devices/lab_pin.sym} 2100 -1140 0 0 {name=p128 lab=vctrl}
C {symbols/nfet_03v3.sym} 120 -1330 0 0 {name=MLS5_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1360 0 0 {name=p129 lab=s5bar}
C {devices/lab_pin.sym} 100 -1330 0 0 {name=p130 lab=b5}
C {devices/lab_pin.sym} 140 -1300 0 0 {name=p131 lab=0}
C {devices/lab_pin.sym} 140 -1330 0 0 {name=p132 lab=0}
C {symbols/nfet_03v3.sym} 400 -1330 0 0 {name=MLS5_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1360 0 0 {name=p133 lab=s5}
C {devices/lab_pin.sym} 380 -1330 0 0 {name=p134 lab=b5bar}
C {devices/lab_pin.sym} 420 -1300 0 0 {name=p135 lab=0}
C {devices/lab_pin.sym} 420 -1330 0 0 {name=p136 lab=0}
C {symbols/pfet_03v3.sym} 680 -1330 0 0 {name=MLS5_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1300 0 0 {name=p137 lab=s5bar}
C {devices/lab_pin.sym} 660 -1330 0 0 {name=p138 lab=s5}
C {devices/lab_pin.sym} 700 -1360 0 0 {name=p139 lab=vdd}
C {devices/lab_pin.sym} 700 -1330 0 0 {name=p140 lab=vdd}
C {symbols/pfet_03v3.sym} 960 -1330 0 0 {name=MLS5_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1300 0 0 {name=p141 lab=s5}
C {devices/lab_pin.sym} 940 -1330 0 0 {name=p142 lab=s5bar}
C {devices/lab_pin.sym} 980 -1360 0 0 {name=p143 lab=vdd}
C {devices/lab_pin.sym} 980 -1330 0 0 {name=p144 lab=vdd}
C {symbols/nfet_03v3.sym} 1240 -1330 0 0 {name=MLB6_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1360 0 0 {name=p145 lab=b6bar}
C {devices/lab_pin.sym} 1220 -1330 0 0 {name=p146 lab=b6}
C {devices/lab_pin.sym} 1260 -1300 0 0 {name=p147 lab=0}
C {devices/lab_pin.sym} 1260 -1330 0 0 {name=p148 lab=0}
C {symbols/pfet_03v3.sym} 1520 -1330 0 0 {name=MLB6_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1300 0 0 {name=p149 lab=b6bar}
C {devices/lab_pin.sym} 1500 -1330 0 0 {name=p150 lab=b6}
C {devices/lab_pin.sym} 1540 -1360 0 0 {name=p151 lab=vctrl}
C {devices/lab_pin.sym} 1540 -1330 0 0 {name=p152 lab=vctrl}
C {symbols/nfet_03v3.sym} 1800 -1330 0 0 {name=MLS6_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1360 0 0 {name=p153 lab=s6bar}
C {devices/lab_pin.sym} 1780 -1330 0 0 {name=p154 lab=b6}
C {devices/lab_pin.sym} 1820 -1300 0 0 {name=p155 lab=0}
C {devices/lab_pin.sym} 1820 -1330 0 0 {name=p156 lab=0}
C {symbols/nfet_03v3.sym} 2080 -1330 0 0 {name=MLS6_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1360 0 0 {name=p157 lab=s6}
C {devices/lab_pin.sym} 2060 -1330 0 0 {name=p158 lab=b6bar}
C {devices/lab_pin.sym} 2100 -1300 0 0 {name=p159 lab=0}
C {devices/lab_pin.sym} 2100 -1330 0 0 {name=p160 lab=0}
C {symbols/pfet_03v3.sym} 120 -1520 0 0 {name=MLS6_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1490 0 0 {name=p161 lab=s6bar}
C {devices/lab_pin.sym} 100 -1520 0 0 {name=p162 lab=s6}
C {devices/lab_pin.sym} 140 -1550 0 0 {name=p163 lab=vdd}
C {devices/lab_pin.sym} 140 -1520 0 0 {name=p164 lab=vdd}
C {symbols/pfet_03v3.sym} 400 -1520 0 0 {name=MLS6_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1490 0 0 {name=p165 lab=s6}
C {devices/lab_pin.sym} 380 -1520 0 0 {name=p166 lab=s6bar}
C {devices/lab_pin.sym} 420 -1550 0 0 {name=p167 lab=vdd}
C {devices/lab_pin.sym} 420 -1520 0 0 {name=p168 lab=vdd}
C {symbols/nfet_03v3.sym} 680 -1520 0 0 {name=MLB7_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1550 0 0 {name=p169 lab=b7bar}
C {devices/lab_pin.sym} 660 -1520 0 0 {name=p170 lab=b7}
C {devices/lab_pin.sym} 700 -1490 0 0 {name=p171 lab=0}
C {devices/lab_pin.sym} 700 -1520 0 0 {name=p172 lab=0}
C {symbols/pfet_03v3.sym} 960 -1520 0 0 {name=MLB7_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1490 0 0 {name=p173 lab=b7bar}
C {devices/lab_pin.sym} 940 -1520 0 0 {name=p174 lab=b7}
C {devices/lab_pin.sym} 980 -1550 0 0 {name=p175 lab=vctrl}
C {devices/lab_pin.sym} 980 -1520 0 0 {name=p176 lab=vctrl}
C {symbols/nfet_03v3.sym} 1240 -1520 0 0 {name=MLS7_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1550 0 0 {name=p177 lab=s7bar}
C {devices/lab_pin.sym} 1220 -1520 0 0 {name=p178 lab=b7}
C {devices/lab_pin.sym} 1260 -1490 0 0 {name=p179 lab=0}
C {devices/lab_pin.sym} 1260 -1520 0 0 {name=p180 lab=0}
C {symbols/nfet_03v3.sym} 1520 -1520 0 0 {name=MLS7_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1550 0 0 {name=p181 lab=s7}
C {devices/lab_pin.sym} 1500 -1520 0 0 {name=p182 lab=b7bar}
C {devices/lab_pin.sym} 1540 -1490 0 0 {name=p183 lab=0}
C {devices/lab_pin.sym} 1540 -1520 0 0 {name=p184 lab=0}
C {symbols/pfet_03v3.sym} 1800 -1520 0 0 {name=MLS7_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1490 0 0 {name=p185 lab=s7bar}
C {devices/lab_pin.sym} 1780 -1520 0 0 {name=p186 lab=s7}
C {devices/lab_pin.sym} 1820 -1550 0 0 {name=p187 lab=vdd}
C {devices/lab_pin.sym} 1820 -1520 0 0 {name=p188 lab=vdd}
C {symbols/pfet_03v3.sym} 2080 -1520 0 0 {name=MLS7_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1490 0 0 {name=p189 lab=s7}
C {devices/lab_pin.sym} 2060 -1520 0 0 {name=p190 lab=s7bar}
C {devices/lab_pin.sym} 2100 -1550 0 0 {name=p191 lab=vdd}
C {devices/lab_pin.sym} 2100 -1520 0 0 {name=p192 lab=vdd}
C {symbols/nfet_03v3.sym} 120 -1710 0 0 {name=MLB8_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1740 0 0 {name=p193 lab=b8bar}
C {devices/lab_pin.sym} 100 -1710 0 0 {name=p194 lab=b8}
C {devices/lab_pin.sym} 140 -1680 0 0 {name=p195 lab=0}
C {devices/lab_pin.sym} 140 -1710 0 0 {name=p196 lab=0}
C {symbols/pfet_03v3.sym} 400 -1710 0 0 {name=MLB8_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1680 0 0 {name=p197 lab=b8bar}
C {devices/lab_pin.sym} 380 -1710 0 0 {name=p198 lab=b8}
C {devices/lab_pin.sym} 420 -1740 0 0 {name=p199 lab=vctrl}
C {devices/lab_pin.sym} 420 -1710 0 0 {name=p200 lab=vctrl}
C {symbols/nfet_03v3.sym} 680 -1710 0 0 {name=MLS8_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1740 0 0 {name=p201 lab=s8bar}
C {devices/lab_pin.sym} 660 -1710 0 0 {name=p202 lab=b8}
C {devices/lab_pin.sym} 700 -1680 0 0 {name=p203 lab=0}
C {devices/lab_pin.sym} 700 -1710 0 0 {name=p204 lab=0}
C {symbols/nfet_03v3.sym} 960 -1710 0 0 {name=MLS8_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1740 0 0 {name=p205 lab=s8}
C {devices/lab_pin.sym} 940 -1710 0 0 {name=p206 lab=b8bar}
C {devices/lab_pin.sym} 980 -1680 0 0 {name=p207 lab=0}
C {devices/lab_pin.sym} 980 -1710 0 0 {name=p208 lab=0}
C {symbols/pfet_03v3.sym} 1240 -1710 0 0 {name=MLS8_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1260 -1680 0 0 {name=p209 lab=s8bar}
C {devices/lab_pin.sym} 1220 -1710 0 0 {name=p210 lab=s8}
C {devices/lab_pin.sym} 1260 -1740 0 0 {name=p211 lab=vdd}
C {devices/lab_pin.sym} 1260 -1710 0 0 {name=p212 lab=vdd}
C {symbols/pfet_03v3.sym} 1520 -1710 0 0 {name=MLS8_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1540 -1680 0 0 {name=p213 lab=s8}
C {devices/lab_pin.sym} 1500 -1710 0 0 {name=p214 lab=s8bar}
C {devices/lab_pin.sym} 1540 -1740 0 0 {name=p215 lab=vdd}
C {devices/lab_pin.sym} 1540 -1710 0 0 {name=p216 lab=vdd}
C {symbols/nfet_03v3.sym} 1800 -1710 0 0 {name=MLMAIN_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 1820 -1740 0 0 {name=p217 lab=mainbar}
C {devices/lab_pin.sym} 1780 -1710 0 0 {name=p218 lab=main}
C {devices/lab_pin.sym} 1820 -1680 0 0 {name=p219 lab=0}
C {devices/lab_pin.sym} 1820 -1710 0 0 {name=p220 lab=0}
C {symbols/pfet_03v3.sym} 2080 -1710 0 0 {name=MLMAIN_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 2100 -1680 0 0 {name=p221 lab=mainbar}
C {devices/lab_pin.sym} 2060 -1710 0 0 {name=p222 lab=main}
C {devices/lab_pin.sym} 2100 -1740 0 0 {name=p223 lab=vctrl}
C {devices/lab_pin.sym} 2100 -1710 0 0 {name=p224 lab=vctrl}
C {symbols/nfet_03v3.sym} 120 -1900 0 0 {name=MLSMAIN_N0 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -1930 0 0 {name=p225 lab=smainbar}
C {devices/lab_pin.sym} 100 -1900 0 0 {name=p226 lab=main}
C {devices/lab_pin.sym} 140 -1870 0 0 {name=p227 lab=0}
C {devices/lab_pin.sym} 140 -1900 0 0 {name=p228 lab=0}
C {symbols/nfet_03v3.sym} 400 -1900 0 0 {name=MLSMAIN_N1 L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -1930 0 0 {name=p229 lab=smain}
C {devices/lab_pin.sym} 380 -1900 0 0 {name=p230 lab=mainbar}
C {devices/lab_pin.sym} 420 -1870 0 0 {name=p231 lab=0}
C {devices/lab_pin.sym} 420 -1900 0 0 {name=p232 lab=0}
C {symbols/pfet_03v3.sym} 680 -1900 0 0 {name=MLSMAIN_P0 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -1870 0 0 {name=p233 lab=smainbar}
C {devices/lab_pin.sym} 660 -1900 0 0 {name=p234 lab=smain}
C {devices/lab_pin.sym} 700 -1930 0 0 {name=p235 lab=vdd}
C {devices/lab_pin.sym} 700 -1900 0 0 {name=p236 lab=vdd}
C {symbols/pfet_03v3.sym} 960 -1900 0 0 {name=MLSMAIN_P1 L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -1870 0 0 {name=p237 lab=smain}
C {devices/lab_pin.sym} 940 -1900 0 0 {name=p238 lab=smainbar}
C {devices/lab_pin.sym} 980 -1930 0 0 {name=p239 lab=vdd}
C {devices/lab_pin.sym} 980 -1900 0 0 {name=p240 lab=vdd}
T {RING — PDK symbols; nets use named labels} 80 -2090 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -2470 0 0 {name=MINV0_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -2500 0 0 {name=p241 lab=d0}
C {devices/lab_pin.sym} 100 -2470 0 0 {name=p242 lab=n2}
C {devices/lab_pin.sym} 140 -2440 0 0 {name=p243 lab=0}
C {devices/lab_pin.sym} 140 -2470 0 0 {name=p244 lab=0}
C {symbols/pfet_03v3.sym} 400 -2470 0 0 {name=MINV0_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -2440 0 0 {name=p245 lab=d0}
C {devices/lab_pin.sym} 380 -2470 0 0 {name=p246 lab=n2}
C {devices/lab_pin.sym} 420 -2500 0 0 {name=p247 lab=vdd}
C {devices/lab_pin.sym} 420 -2470 0 0 {name=p248 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -2660 0 0 0.35 0.35 {}
C {symbols/ppolyf_u_1k.sym} 120 -3040 0 0 {name=RRDELAY0 model=ppolyf_u_1k W=1u L=440u m=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -3070 0 0 {name=p249 lab=d0}
C {devices/lab_pin.sym} 120 -3010 0 0 {name=p250 lab=n0}
C {devices/lab_pin.sym} 100 -3040 0 0 {name=p251 lab=0}
C {symbols/cap_mim_analog.sym} 400 -3040 0 0 {name=CCBASE0 model=cap_mim_2f0_m4m5_noshield m=1 W=15.6u L=15.6u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -3070 0 0 {name=p252 lab=n0}
C {devices/lab_pin.sym} 400 -3010 0 0 {name=p253 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -3230 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -3610 0 0 {name=MMAIN0_N L=0.28u W=8u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -3640 0 0 {name=p254 lab=n0}
C {devices/lab_pin.sym} 100 -3610 0 0 {name=p255 lab=smain}
C {devices/lab_pin.sym} 140 -3580 0 0 {name=p256 lab=bank0}
C {devices/lab_pin.sym} 140 -3610 0 0 {name=p257 lab=0}
C {symbols/pfet_03v3.sym} 400 -3610 0 0 {name=MMAIN0_P L=0.28u W=16u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -3580 0 0 {name=p258 lab=n0}
C {devices/lab_pin.sym} 380 -3610 0 0 {name=p259 lab=smainbar}
C {devices/lab_pin.sym} 420 -3640 0 0 {name=p260 lab=bank0}
C {devices/lab_pin.sym} 420 -3610 0 0 {name=p261 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -3800 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -4180 0 0 {name=MSW0_0_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -4210 0 0 {name=p262 lab=bank0}
C {devices/lab_pin.sym} 100 -4180 0 0 {name=p263 lab=s0}
C {devices/lab_pin.sym} 140 -4150 0 0 {name=p264 lab=cap0_0}
C {devices/lab_pin.sym} 140 -4180 0 0 {name=p265 lab=0}
C {symbols/pfet_03v3.sym} 400 -4180 0 0 {name=MSW0_0_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -4150 0 0 {name=p266 lab=bank0}
C {devices/lab_pin.sym} 380 -4180 0 0 {name=p267 lab=s0bar}
C {devices/lab_pin.sym} 420 -4210 0 0 {name=p268 lab=cap0_0}
C {devices/lab_pin.sym} 420 -4180 0 0 {name=p269 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -4370 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -4750 0 0 {name=CC0_0_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -4780 0 0 {name=p270 lab=cap0_0}
C {devices/lab_pin.sym} 120 -4720 0 0 {name=p271 lab=mid0_0_0_0}
C {symbols/cap_mim_analog.sym} 400 -4750 0 0 {name=CC0_0_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -4780 0 0 {name=p272 lab=mid0_0_0_0}
C {devices/lab_pin.sym} 400 -4720 0 0 {name=p273 lab=mid0_0_0_1}
C {symbols/cap_mim_analog.sym} 680 -4750 0 0 {name=CC0_0_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -4780 0 0 {name=p274 lab=mid0_0_0_1}
C {devices/lab_pin.sym} 680 -4720 0 0 {name=p275 lab=mid0_0_0_2}
C {symbols/cap_mim_analog.sym} 960 -4750 0 0 {name=CC0_0_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -4780 0 0 {name=p276 lab=mid0_0_0_2}
C {devices/lab_pin.sym} 960 -4720 0 0 {name=p277 lab=mid0_0_0_3}
C {symbols/cap_mim_analog.sym} 1240 -4750 0 0 {name=CC0_0_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -4780 0 0 {name=p278 lab=mid0_0_0_3}
C {devices/lab_pin.sym} 1240 -4720 0 0 {name=p279 lab=mid0_0_0_4}
C {symbols/cap_mim_analog.sym} 1520 -4750 0 0 {name=CC0_0_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -4780 0 0 {name=p280 lab=mid0_0_0_4}
C {devices/lab_pin.sym} 1520 -4720 0 0 {name=p281 lab=mid0_0_0_5}
C {symbols/cap_mim_analog.sym} 1800 -4750 0 0 {name=CC0_0_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -4780 0 0 {name=p282 lab=mid0_0_0_5}
C {devices/lab_pin.sym} 1800 -4720 0 0 {name=p283 lab=mid0_0_0_6}
C {symbols/cap_mim_analog.sym} 2080 -4750 0 0 {name=CC0_0_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -4780 0 0 {name=p284 lab=mid0_0_0_6}
C {devices/lab_pin.sym} 2080 -4720 0 0 {name=p285 lab=mid0_0_0_7}
C {symbols/cap_mim_analog.sym} 120 -4940 0 0 {name=CC0_0_0_8 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -4970 0 0 {name=p286 lab=mid0_0_0_7}
C {devices/lab_pin.sym} 120 -4910 0 0 {name=p287 lab=mid0_0_0_8}
C {symbols/cap_mim_analog.sym} 400 -4940 0 0 {name=CC0_0_0_9 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -4970 0 0 {name=p288 lab=mid0_0_0_8}
C {devices/lab_pin.sym} 400 -4910 0 0 {name=p289 lab=mid0_0_0_9}
C {symbols/cap_mim_analog.sym} 680 -4940 0 0 {name=CC0_0_0_10 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -4970 0 0 {name=p290 lab=mid0_0_0_9}
C {devices/lab_pin.sym} 680 -4910 0 0 {name=p291 lab=mid0_0_0_10}
C {symbols/cap_mim_analog.sym} 960 -4940 0 0 {name=CC0_0_0_11 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -4970 0 0 {name=p292 lab=mid0_0_0_10}
C {devices/lab_pin.sym} 960 -4910 0 0 {name=p293 lab=mid0_0_0_11}
C {symbols/cap_mim_analog.sym} 1240 -4940 0 0 {name=CC0_0_0_12 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -4970 0 0 {name=p294 lab=mid0_0_0_11}
C {devices/lab_pin.sym} 1240 -4910 0 0 {name=p295 lab=mid0_0_0_12}
C {symbols/cap_mim_analog.sym} 1520 -4940 0 0 {name=CC0_0_0_13 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -4970 0 0 {name=p296 lab=mid0_0_0_12}
C {devices/lab_pin.sym} 1520 -4910 0 0 {name=p297 lab=mid0_0_0_13}
C {symbols/cap_mim_analog.sym} 1800 -4940 0 0 {name=CC0_0_0_14 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -4970 0 0 {name=p298 lab=mid0_0_0_13}
C {devices/lab_pin.sym} 1800 -4910 0 0 {name=p299 lab=mid0_0_0_14}
C {symbols/cap_mim_analog.sym} 2080 -4940 0 0 {name=CC0_0_0_15 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -4970 0 0 {name=p300 lab=mid0_0_0_14}
C {devices/lab_pin.sym} 2080 -4910 0 0 {name=p301 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -5130 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -5510 0 0 {name=MSW0_1_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -5540 0 0 {name=p302 lab=bank0}
C {devices/lab_pin.sym} 100 -5510 0 0 {name=p303 lab=s1}
C {devices/lab_pin.sym} 140 -5480 0 0 {name=p304 lab=cap0_1}
C {devices/lab_pin.sym} 140 -5510 0 0 {name=p305 lab=0}
C {symbols/pfet_03v3.sym} 400 -5510 0 0 {name=MSW0_1_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -5480 0 0 {name=p306 lab=bank0}
C {devices/lab_pin.sym} 380 -5510 0 0 {name=p307 lab=s1bar}
C {devices/lab_pin.sym} 420 -5540 0 0 {name=p308 lab=cap0_1}
C {devices/lab_pin.sym} 420 -5510 0 0 {name=p309 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -5700 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -6080 0 0 {name=CC0_1_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -6110 0 0 {name=p310 lab=cap0_1}
C {devices/lab_pin.sym} 120 -6050 0 0 {name=p311 lab=mid0_1_0_0}
C {symbols/cap_mim_analog.sym} 400 -6080 0 0 {name=CC0_1_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -6110 0 0 {name=p312 lab=mid0_1_0_0}
C {devices/lab_pin.sym} 400 -6050 0 0 {name=p313 lab=mid0_1_0_1}
C {symbols/cap_mim_analog.sym} 680 -6080 0 0 {name=CC0_1_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -6110 0 0 {name=p314 lab=mid0_1_0_1}
C {devices/lab_pin.sym} 680 -6050 0 0 {name=p315 lab=mid0_1_0_2}
C {symbols/cap_mim_analog.sym} 960 -6080 0 0 {name=CC0_1_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -6110 0 0 {name=p316 lab=mid0_1_0_2}
C {devices/lab_pin.sym} 960 -6050 0 0 {name=p317 lab=mid0_1_0_3}
C {symbols/cap_mim_analog.sym} 1240 -6080 0 0 {name=CC0_1_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -6110 0 0 {name=p318 lab=mid0_1_0_3}
C {devices/lab_pin.sym} 1240 -6050 0 0 {name=p319 lab=mid0_1_0_4}
C {symbols/cap_mim_analog.sym} 1520 -6080 0 0 {name=CC0_1_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -6110 0 0 {name=p320 lab=mid0_1_0_4}
C {devices/lab_pin.sym} 1520 -6050 0 0 {name=p321 lab=mid0_1_0_5}
C {symbols/cap_mim_analog.sym} 1800 -6080 0 0 {name=CC0_1_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -6110 0 0 {name=p322 lab=mid0_1_0_5}
C {devices/lab_pin.sym} 1800 -6050 0 0 {name=p323 lab=mid0_1_0_6}
C {symbols/cap_mim_analog.sym} 2080 -6080 0 0 {name=CC0_1_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -6110 0 0 {name=p324 lab=mid0_1_0_6}
C {devices/lab_pin.sym} 2080 -6050 0 0 {name=p325 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -6270 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -6650 0 0 {name=MSW0_2_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -6680 0 0 {name=p326 lab=bank0}
C {devices/lab_pin.sym} 100 -6650 0 0 {name=p327 lab=s2}
C {devices/lab_pin.sym} 140 -6620 0 0 {name=p328 lab=cap0_2}
C {devices/lab_pin.sym} 140 -6650 0 0 {name=p329 lab=0}
C {symbols/pfet_03v3.sym} 400 -6650 0 0 {name=MSW0_2_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -6620 0 0 {name=p330 lab=bank0}
C {devices/lab_pin.sym} 380 -6650 0 0 {name=p331 lab=s2bar}
C {devices/lab_pin.sym} 420 -6680 0 0 {name=p332 lab=cap0_2}
C {devices/lab_pin.sym} 420 -6650 0 0 {name=p333 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -6840 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -7220 0 0 {name=CC0_2_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -7250 0 0 {name=p334 lab=cap0_2}
C {devices/lab_pin.sym} 120 -7190 0 0 {name=p335 lab=mid0_2_0_0}
C {symbols/cap_mim_analog.sym} 400 -7220 0 0 {name=CC0_2_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -7250 0 0 {name=p336 lab=mid0_2_0_0}
C {devices/lab_pin.sym} 400 -7190 0 0 {name=p337 lab=mid0_2_0_1}
C {symbols/cap_mim_analog.sym} 680 -7220 0 0 {name=CC0_2_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -7250 0 0 {name=p338 lab=mid0_2_0_1}
C {devices/lab_pin.sym} 680 -7190 0 0 {name=p339 lab=mid0_2_0_2}
C {symbols/cap_mim_analog.sym} 960 -7220 0 0 {name=CC0_2_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -7250 0 0 {name=p340 lab=mid0_2_0_2}
C {devices/lab_pin.sym} 960 -7190 0 0 {name=p341 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -7410 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -7790 0 0 {name=MSW0_3_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -7820 0 0 {name=p342 lab=bank0}
C {devices/lab_pin.sym} 100 -7790 0 0 {name=p343 lab=s3}
C {devices/lab_pin.sym} 140 -7760 0 0 {name=p344 lab=cap0_3}
C {devices/lab_pin.sym} 140 -7790 0 0 {name=p345 lab=0}
C {symbols/pfet_03v3.sym} 400 -7790 0 0 {name=MSW0_3_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -7760 0 0 {name=p346 lab=bank0}
C {devices/lab_pin.sym} 380 -7790 0 0 {name=p347 lab=s3bar}
C {devices/lab_pin.sym} 420 -7820 0 0 {name=p348 lab=cap0_3}
C {devices/lab_pin.sym} 420 -7790 0 0 {name=p349 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -7980 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -8360 0 0 {name=CC0_3_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -8390 0 0 {name=p350 lab=cap0_3}
C {devices/lab_pin.sym} 120 -8330 0 0 {name=p351 lab=mid0_3_0_0}
C {symbols/cap_mim_analog.sym} 400 -8360 0 0 {name=CC0_3_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -8390 0 0 {name=p352 lab=mid0_3_0_0}
C {devices/lab_pin.sym} 400 -8330 0 0 {name=p353 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -8550 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -8930 0 0 {name=MSW0_4_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -8960 0 0 {name=p354 lab=bank0}
C {devices/lab_pin.sym} 100 -8930 0 0 {name=p355 lab=s4}
C {devices/lab_pin.sym} 140 -8900 0 0 {name=p356 lab=cap0_4}
C {devices/lab_pin.sym} 140 -8930 0 0 {name=p357 lab=0}
C {symbols/pfet_03v3.sym} 400 -8930 0 0 {name=MSW0_4_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -8900 0 0 {name=p358 lab=bank0}
C {devices/lab_pin.sym} 380 -8930 0 0 {name=p359 lab=s4bar}
C {devices/lab_pin.sym} 420 -8960 0 0 {name=p360 lab=cap0_4}
C {devices/lab_pin.sym} 420 -8930 0 0 {name=p361 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -9120 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -9500 0 0 {name=CC0_4_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.7u L=6.7u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -9530 0 0 {name=p362 lab=cap0_4}
C {devices/lab_pin.sym} 120 -9470 0 0 {name=p363 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -9690 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -10070 0 0 {name=MSW0_5_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -10100 0 0 {name=p364 lab=bank0}
C {devices/lab_pin.sym} 100 -10070 0 0 {name=p365 lab=s5}
C {devices/lab_pin.sym} 140 -10040 0 0 {name=p366 lab=cap0_5}
C {devices/lab_pin.sym} 140 -10070 0 0 {name=p367 lab=0}
C {symbols/pfet_03v3.sym} 400 -10070 0 0 {name=MSW0_5_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -10040 0 0 {name=p368 lab=bank0}
C {devices/lab_pin.sym} 380 -10070 0 0 {name=p369 lab=s5bar}
C {devices/lab_pin.sym} 420 -10100 0 0 {name=p370 lab=cap0_5}
C {devices/lab_pin.sym} 420 -10070 0 0 {name=p371 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -10260 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -10640 0 0 {name=CC0_5_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -10670 0 0 {name=p372 lab=cap0_5}
C {devices/lab_pin.sym} 120 -10610 0 0 {name=p373 lab=0}
C {symbols/cap_mim_analog.sym} 400 -10640 0 0 {name=CC0_5_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -10670 0 0 {name=p374 lab=cap0_5}
C {devices/lab_pin.sym} 400 -10610 0 0 {name=p375 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -10830 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -11210 0 0 {name=MSW0_6_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -11240 0 0 {name=p376 lab=bank0}
C {devices/lab_pin.sym} 100 -11210 0 0 {name=p377 lab=s6}
C {devices/lab_pin.sym} 140 -11180 0 0 {name=p378 lab=cap0_6}
C {devices/lab_pin.sym} 140 -11210 0 0 {name=p379 lab=0}
C {symbols/pfet_03v3.sym} 400 -11210 0 0 {name=MSW0_6_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -11180 0 0 {name=p380 lab=bank0}
C {devices/lab_pin.sym} 380 -11210 0 0 {name=p381 lab=s6bar}
C {devices/lab_pin.sym} 420 -11240 0 0 {name=p382 lab=cap0_6}
C {devices/lab_pin.sym} 420 -11210 0 0 {name=p383 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -11400 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -11780 0 0 {name=CC0_6_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -11810 0 0 {name=p384 lab=cap0_6}
C {devices/lab_pin.sym} 120 -11750 0 0 {name=p385 lab=0}
C {symbols/cap_mim_analog.sym} 400 -11780 0 0 {name=CC0_6_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -11810 0 0 {name=p386 lab=cap0_6}
C {devices/lab_pin.sym} 400 -11750 0 0 {name=p387 lab=0}
C {symbols/cap_mim_analog.sym} 680 -11780 0 0 {name=CC0_6_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -11810 0 0 {name=p388 lab=cap0_6}
C {devices/lab_pin.sym} 680 -11750 0 0 {name=p389 lab=0}
C {symbols/cap_mim_analog.sym} 960 -11780 0 0 {name=CC0_6_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -11810 0 0 {name=p390 lab=cap0_6}
C {devices/lab_pin.sym} 960 -11750 0 0 {name=p391 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -11970 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -12350 0 0 {name=MSW0_7_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -12380 0 0 {name=p392 lab=bank0}
C {devices/lab_pin.sym} 100 -12350 0 0 {name=p393 lab=s7}
C {devices/lab_pin.sym} 140 -12320 0 0 {name=p394 lab=cap0_7}
C {devices/lab_pin.sym} 140 -12350 0 0 {name=p395 lab=0}
C {symbols/pfet_03v3.sym} 400 -12350 0 0 {name=MSW0_7_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -12320 0 0 {name=p396 lab=bank0}
C {devices/lab_pin.sym} 380 -12350 0 0 {name=p397 lab=s7bar}
C {devices/lab_pin.sym} 420 -12380 0 0 {name=p398 lab=cap0_7}
C {devices/lab_pin.sym} 420 -12350 0 0 {name=p399 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -12540 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -12920 0 0 {name=CC0_7_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -12950 0 0 {name=p400 lab=cap0_7}
C {devices/lab_pin.sym} 120 -12890 0 0 {name=p401 lab=0}
C {symbols/cap_mim_analog.sym} 400 -12920 0 0 {name=CC0_7_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -12950 0 0 {name=p402 lab=cap0_7}
C {devices/lab_pin.sym} 400 -12890 0 0 {name=p403 lab=0}
C {symbols/cap_mim_analog.sym} 680 -12920 0 0 {name=CC0_7_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -12950 0 0 {name=p404 lab=cap0_7}
C {devices/lab_pin.sym} 680 -12890 0 0 {name=p405 lab=0}
C {symbols/cap_mim_analog.sym} 960 -12920 0 0 {name=CC0_7_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -12950 0 0 {name=p406 lab=cap0_7}
C {devices/lab_pin.sym} 960 -12890 0 0 {name=p407 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -12920 0 0 {name=CC0_7_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -12950 0 0 {name=p408 lab=cap0_7}
C {devices/lab_pin.sym} 1240 -12890 0 0 {name=p409 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -12920 0 0 {name=CC0_7_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -12950 0 0 {name=p410 lab=cap0_7}
C {devices/lab_pin.sym} 1520 -12890 0 0 {name=p411 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -12920 0 0 {name=CC0_7_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -12950 0 0 {name=p412 lab=cap0_7}
C {devices/lab_pin.sym} 1800 -12890 0 0 {name=p413 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -12920 0 0 {name=CC0_7_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -12950 0 0 {name=p414 lab=cap0_7}
C {devices/lab_pin.sym} 2080 -12890 0 0 {name=p415 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -13110 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -13490 0 0 {name=MSW0_8_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -13520 0 0 {name=p416 lab=bank0}
C {devices/lab_pin.sym} 100 -13490 0 0 {name=p417 lab=s8}
C {devices/lab_pin.sym} 140 -13460 0 0 {name=p418 lab=cap0_8}
C {devices/lab_pin.sym} 140 -13490 0 0 {name=p419 lab=0}
C {symbols/pfet_03v3.sym} 400 -13490 0 0 {name=MSW0_8_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -13460 0 0 {name=p420 lab=bank0}
C {devices/lab_pin.sym} 380 -13490 0 0 {name=p421 lab=s8bar}
C {devices/lab_pin.sym} 420 -13520 0 0 {name=p422 lab=cap0_8}
C {devices/lab_pin.sym} 420 -13490 0 0 {name=p423 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -13680 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -14060 0 0 {name=CC0_8_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14090 0 0 {name=p424 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14030 0 0 {name=p425 lab=0}
C {symbols/cap_mim_analog.sym} 400 -14060 0 0 {name=CC0_8_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14090 0 0 {name=p426 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14030 0 0 {name=p427 lab=0}
C {symbols/cap_mim_analog.sym} 680 -14060 0 0 {name=CC0_8_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14090 0 0 {name=p428 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14030 0 0 {name=p429 lab=0}
C {symbols/cap_mim_analog.sym} 960 -14060 0 0 {name=CC0_8_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14090 0 0 {name=p430 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14030 0 0 {name=p431 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -14060 0 0 {name=CC0_8_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14090 0 0 {name=p432 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14030 0 0 {name=p433 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -14060 0 0 {name=CC0_8_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14090 0 0 {name=p434 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14030 0 0 {name=p435 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -14060 0 0 {name=CC0_8_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14090 0 0 {name=p436 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14030 0 0 {name=p437 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -14060 0 0 {name=CC0_8_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14090 0 0 {name=p438 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14030 0 0 {name=p439 lab=0}
C {symbols/cap_mim_analog.sym} 120 -14250 0 0 {name=CC0_8_8_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -14280 0 0 {name=p440 lab=cap0_8}
C {devices/lab_pin.sym} 120 -14220 0 0 {name=p441 lab=0}
C {symbols/cap_mim_analog.sym} 400 -14250 0 0 {name=CC0_8_9_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -14280 0 0 {name=p442 lab=cap0_8}
C {devices/lab_pin.sym} 400 -14220 0 0 {name=p443 lab=0}
C {symbols/cap_mim_analog.sym} 680 -14250 0 0 {name=CC0_8_10_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -14280 0 0 {name=p444 lab=cap0_8}
C {devices/lab_pin.sym} 680 -14220 0 0 {name=p445 lab=0}
C {symbols/cap_mim_analog.sym} 960 -14250 0 0 {name=CC0_8_11_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -14280 0 0 {name=p446 lab=cap0_8}
C {devices/lab_pin.sym} 960 -14220 0 0 {name=p447 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -14250 0 0 {name=CC0_8_12_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -14280 0 0 {name=p448 lab=cap0_8}
C {devices/lab_pin.sym} 1240 -14220 0 0 {name=p449 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -14250 0 0 {name=CC0_8_13_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -14280 0 0 {name=p450 lab=cap0_8}
C {devices/lab_pin.sym} 1520 -14220 0 0 {name=p451 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -14250 0 0 {name=CC0_8_14_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -14280 0 0 {name=p452 lab=cap0_8}
C {devices/lab_pin.sym} 1800 -14220 0 0 {name=p453 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -14250 0 0 {name=CC0_8_15_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -14280 0 0 {name=p454 lab=cap0_8}
C {devices/lab_pin.sym} 2080 -14220 0 0 {name=p455 lab=0}
T {RING — PDK symbols; nets use named labels} 80 -14440 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -14820 0 0 {name=MINV1_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -14850 0 0 {name=p456 lab=d1}
C {devices/lab_pin.sym} 100 -14820 0 0 {name=p457 lab=n0}
C {devices/lab_pin.sym} 140 -14790 0 0 {name=p458 lab=0}
C {devices/lab_pin.sym} 140 -14820 0 0 {name=p459 lab=0}
C {symbols/pfet_03v3.sym} 400 -14820 0 0 {name=MINV1_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -14790 0 0 {name=p460 lab=d1}
C {devices/lab_pin.sym} 380 -14820 0 0 {name=p461 lab=n0}
C {devices/lab_pin.sym} 420 -14850 0 0 {name=p462 lab=vdd}
C {devices/lab_pin.sym} 420 -14820 0 0 {name=p463 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -15010 0 0 0.35 0.35 {}
C {symbols/ppolyf_u_1k.sym} 120 -15390 0 0 {name=RRDELAY1 model=ppolyf_u_1k W=1u L=440u m=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -15420 0 0 {name=p464 lab=d1}
C {devices/lab_pin.sym} 120 -15360 0 0 {name=p465 lab=n1}
C {devices/lab_pin.sym} 100 -15390 0 0 {name=p466 lab=0}
C {symbols/cap_mim_analog.sym} 400 -15390 0 0 {name=CCBASE1 model=cap_mim_2f0_m4m5_noshield m=1 W=15.6u L=15.6u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -15420 0 0 {name=p467 lab=n1}
C {devices/lab_pin.sym} 400 -15360 0 0 {name=p468 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -15580 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -15960 0 0 {name=MMAIN1_N L=0.28u W=8u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -15990 0 0 {name=p469 lab=n1}
C {devices/lab_pin.sym} 100 -15960 0 0 {name=p470 lab=smain}
C {devices/lab_pin.sym} 140 -15930 0 0 {name=p471 lab=bank1}
C {devices/lab_pin.sym} 140 -15960 0 0 {name=p472 lab=0}
C {symbols/pfet_03v3.sym} 400 -15960 0 0 {name=MMAIN1_P L=0.28u W=16u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -15930 0 0 {name=p473 lab=n1}
C {devices/lab_pin.sym} 380 -15960 0 0 {name=p474 lab=smainbar}
C {devices/lab_pin.sym} 420 -15990 0 0 {name=p475 lab=bank1}
C {devices/lab_pin.sym} 420 -15960 0 0 {name=p476 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -16150 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -16530 0 0 {name=MSW1_0_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -16560 0 0 {name=p477 lab=bank1}
C {devices/lab_pin.sym} 100 -16530 0 0 {name=p478 lab=s0}
C {devices/lab_pin.sym} 140 -16500 0 0 {name=p479 lab=cap1_0}
C {devices/lab_pin.sym} 140 -16530 0 0 {name=p480 lab=0}
C {symbols/pfet_03v3.sym} 400 -16530 0 0 {name=MSW1_0_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -16500 0 0 {name=p481 lab=bank1}
C {devices/lab_pin.sym} 380 -16530 0 0 {name=p482 lab=s0bar}
C {devices/lab_pin.sym} 420 -16560 0 0 {name=p483 lab=cap1_0}
C {devices/lab_pin.sym} 420 -16530 0 0 {name=p484 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -16720 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -17100 0 0 {name=CC1_0_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -17130 0 0 {name=p485 lab=cap1_0}
C {devices/lab_pin.sym} 120 -17070 0 0 {name=p486 lab=mid1_0_0_0}
C {symbols/cap_mim_analog.sym} 400 -17100 0 0 {name=CC1_0_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -17130 0 0 {name=p487 lab=mid1_0_0_0}
C {devices/lab_pin.sym} 400 -17070 0 0 {name=p488 lab=mid1_0_0_1}
C {symbols/cap_mim_analog.sym} 680 -17100 0 0 {name=CC1_0_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -17130 0 0 {name=p489 lab=mid1_0_0_1}
C {devices/lab_pin.sym} 680 -17070 0 0 {name=p490 lab=mid1_0_0_2}
C {symbols/cap_mim_analog.sym} 960 -17100 0 0 {name=CC1_0_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -17130 0 0 {name=p491 lab=mid1_0_0_2}
C {devices/lab_pin.sym} 960 -17070 0 0 {name=p492 lab=mid1_0_0_3}
C {symbols/cap_mim_analog.sym} 1240 -17100 0 0 {name=CC1_0_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -17130 0 0 {name=p493 lab=mid1_0_0_3}
C {devices/lab_pin.sym} 1240 -17070 0 0 {name=p494 lab=mid1_0_0_4}
C {symbols/cap_mim_analog.sym} 1520 -17100 0 0 {name=CC1_0_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -17130 0 0 {name=p495 lab=mid1_0_0_4}
C {devices/lab_pin.sym} 1520 -17070 0 0 {name=p496 lab=mid1_0_0_5}
C {symbols/cap_mim_analog.sym} 1800 -17100 0 0 {name=CC1_0_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -17130 0 0 {name=p497 lab=mid1_0_0_5}
C {devices/lab_pin.sym} 1800 -17070 0 0 {name=p498 lab=mid1_0_0_6}
C {symbols/cap_mim_analog.sym} 2080 -17100 0 0 {name=CC1_0_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -17130 0 0 {name=p499 lab=mid1_0_0_6}
C {devices/lab_pin.sym} 2080 -17070 0 0 {name=p500 lab=mid1_0_0_7}
C {symbols/cap_mim_analog.sym} 120 -17290 0 0 {name=CC1_0_0_8 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -17320 0 0 {name=p501 lab=mid1_0_0_7}
C {devices/lab_pin.sym} 120 -17260 0 0 {name=p502 lab=mid1_0_0_8}
C {symbols/cap_mim_analog.sym} 400 -17290 0 0 {name=CC1_0_0_9 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -17320 0 0 {name=p503 lab=mid1_0_0_8}
C {devices/lab_pin.sym} 400 -17260 0 0 {name=p504 lab=mid1_0_0_9}
C {symbols/cap_mim_analog.sym} 680 -17290 0 0 {name=CC1_0_0_10 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -17320 0 0 {name=p505 lab=mid1_0_0_9}
C {devices/lab_pin.sym} 680 -17260 0 0 {name=p506 lab=mid1_0_0_10}
C {symbols/cap_mim_analog.sym} 960 -17290 0 0 {name=CC1_0_0_11 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -17320 0 0 {name=p507 lab=mid1_0_0_10}
C {devices/lab_pin.sym} 960 -17260 0 0 {name=p508 lab=mid1_0_0_11}
C {symbols/cap_mim_analog.sym} 1240 -17290 0 0 {name=CC1_0_0_12 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -17320 0 0 {name=p509 lab=mid1_0_0_11}
C {devices/lab_pin.sym} 1240 -17260 0 0 {name=p510 lab=mid1_0_0_12}
C {symbols/cap_mim_analog.sym} 1520 -17290 0 0 {name=CC1_0_0_13 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -17320 0 0 {name=p511 lab=mid1_0_0_12}
C {devices/lab_pin.sym} 1520 -17260 0 0 {name=p512 lab=mid1_0_0_13}
C {symbols/cap_mim_analog.sym} 1800 -17290 0 0 {name=CC1_0_0_14 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -17320 0 0 {name=p513 lab=mid1_0_0_13}
C {devices/lab_pin.sym} 1800 -17260 0 0 {name=p514 lab=mid1_0_0_14}
C {symbols/cap_mim_analog.sym} 2080 -17290 0 0 {name=CC1_0_0_15 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -17320 0 0 {name=p515 lab=mid1_0_0_14}
C {devices/lab_pin.sym} 2080 -17260 0 0 {name=p516 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -17480 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -17860 0 0 {name=MSW1_1_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -17890 0 0 {name=p517 lab=bank1}
C {devices/lab_pin.sym} 100 -17860 0 0 {name=p518 lab=s1}
C {devices/lab_pin.sym} 140 -17830 0 0 {name=p519 lab=cap1_1}
C {devices/lab_pin.sym} 140 -17860 0 0 {name=p520 lab=0}
C {symbols/pfet_03v3.sym} 400 -17860 0 0 {name=MSW1_1_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -17830 0 0 {name=p521 lab=bank1}
C {devices/lab_pin.sym} 380 -17860 0 0 {name=p522 lab=s1bar}
C {devices/lab_pin.sym} 420 -17890 0 0 {name=p523 lab=cap1_1}
C {devices/lab_pin.sym} 420 -17860 0 0 {name=p524 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -18050 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -18430 0 0 {name=CC1_1_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -18460 0 0 {name=p525 lab=cap1_1}
C {devices/lab_pin.sym} 120 -18400 0 0 {name=p526 lab=mid1_1_0_0}
C {symbols/cap_mim_analog.sym} 400 -18430 0 0 {name=CC1_1_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -18460 0 0 {name=p527 lab=mid1_1_0_0}
C {devices/lab_pin.sym} 400 -18400 0 0 {name=p528 lab=mid1_1_0_1}
C {symbols/cap_mim_analog.sym} 680 -18430 0 0 {name=CC1_1_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -18460 0 0 {name=p529 lab=mid1_1_0_1}
C {devices/lab_pin.sym} 680 -18400 0 0 {name=p530 lab=mid1_1_0_2}
C {symbols/cap_mim_analog.sym} 960 -18430 0 0 {name=CC1_1_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -18460 0 0 {name=p531 lab=mid1_1_0_2}
C {devices/lab_pin.sym} 960 -18400 0 0 {name=p532 lab=mid1_1_0_3}
C {symbols/cap_mim_analog.sym} 1240 -18430 0 0 {name=CC1_1_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -18460 0 0 {name=p533 lab=mid1_1_0_3}
C {devices/lab_pin.sym} 1240 -18400 0 0 {name=p534 lab=mid1_1_0_4}
C {symbols/cap_mim_analog.sym} 1520 -18430 0 0 {name=CC1_1_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -18460 0 0 {name=p535 lab=mid1_1_0_4}
C {devices/lab_pin.sym} 1520 -18400 0 0 {name=p536 lab=mid1_1_0_5}
C {symbols/cap_mim_analog.sym} 1800 -18430 0 0 {name=CC1_1_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -18460 0 0 {name=p537 lab=mid1_1_0_5}
C {devices/lab_pin.sym} 1800 -18400 0 0 {name=p538 lab=mid1_1_0_6}
C {symbols/cap_mim_analog.sym} 2080 -18430 0 0 {name=CC1_1_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -18460 0 0 {name=p539 lab=mid1_1_0_6}
C {devices/lab_pin.sym} 2080 -18400 0 0 {name=p540 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -18620 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -19000 0 0 {name=MSW1_2_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -19030 0 0 {name=p541 lab=bank1}
C {devices/lab_pin.sym} 100 -19000 0 0 {name=p542 lab=s2}
C {devices/lab_pin.sym} 140 -18970 0 0 {name=p543 lab=cap1_2}
C {devices/lab_pin.sym} 140 -19000 0 0 {name=p544 lab=0}
C {symbols/pfet_03v3.sym} 400 -19000 0 0 {name=MSW1_2_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -18970 0 0 {name=p545 lab=bank1}
C {devices/lab_pin.sym} 380 -19000 0 0 {name=p546 lab=s2bar}
C {devices/lab_pin.sym} 420 -19030 0 0 {name=p547 lab=cap1_2}
C {devices/lab_pin.sym} 420 -19000 0 0 {name=p548 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -19190 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -19570 0 0 {name=CC1_2_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -19600 0 0 {name=p549 lab=cap1_2}
C {devices/lab_pin.sym} 120 -19540 0 0 {name=p550 lab=mid1_2_0_0}
C {symbols/cap_mim_analog.sym} 400 -19570 0 0 {name=CC1_2_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -19600 0 0 {name=p551 lab=mid1_2_0_0}
C {devices/lab_pin.sym} 400 -19540 0 0 {name=p552 lab=mid1_2_0_1}
C {symbols/cap_mim_analog.sym} 680 -19570 0 0 {name=CC1_2_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -19600 0 0 {name=p553 lab=mid1_2_0_1}
C {devices/lab_pin.sym} 680 -19540 0 0 {name=p554 lab=mid1_2_0_2}
C {symbols/cap_mim_analog.sym} 960 -19570 0 0 {name=CC1_2_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -19600 0 0 {name=p555 lab=mid1_2_0_2}
C {devices/lab_pin.sym} 960 -19540 0 0 {name=p556 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -19760 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -20140 0 0 {name=MSW1_3_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -20170 0 0 {name=p557 lab=bank1}
C {devices/lab_pin.sym} 100 -20140 0 0 {name=p558 lab=s3}
C {devices/lab_pin.sym} 140 -20110 0 0 {name=p559 lab=cap1_3}
C {devices/lab_pin.sym} 140 -20140 0 0 {name=p560 lab=0}
C {symbols/pfet_03v3.sym} 400 -20140 0 0 {name=MSW1_3_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -20110 0 0 {name=p561 lab=bank1}
C {devices/lab_pin.sym} 380 -20140 0 0 {name=p562 lab=s3bar}
C {devices/lab_pin.sym} 420 -20170 0 0 {name=p563 lab=cap1_3}
C {devices/lab_pin.sym} 420 -20140 0 0 {name=p564 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -20330 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -20710 0 0 {name=CC1_3_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -20740 0 0 {name=p565 lab=cap1_3}
C {devices/lab_pin.sym} 120 -20680 0 0 {name=p566 lab=mid1_3_0_0}
C {symbols/cap_mim_analog.sym} 400 -20710 0 0 {name=CC1_3_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -20740 0 0 {name=p567 lab=mid1_3_0_0}
C {devices/lab_pin.sym} 400 -20680 0 0 {name=p568 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -20900 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -21280 0 0 {name=MSW1_4_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -21310 0 0 {name=p569 lab=bank1}
C {devices/lab_pin.sym} 100 -21280 0 0 {name=p570 lab=s4}
C {devices/lab_pin.sym} 140 -21250 0 0 {name=p571 lab=cap1_4}
C {devices/lab_pin.sym} 140 -21280 0 0 {name=p572 lab=0}
C {symbols/pfet_03v3.sym} 400 -21280 0 0 {name=MSW1_4_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -21250 0 0 {name=p573 lab=bank1}
C {devices/lab_pin.sym} 380 -21280 0 0 {name=p574 lab=s4bar}
C {devices/lab_pin.sym} 420 -21310 0 0 {name=p575 lab=cap1_4}
C {devices/lab_pin.sym} 420 -21280 0 0 {name=p576 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -21470 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -21850 0 0 {name=CC1_4_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.7u L=6.7u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -21880 0 0 {name=p577 lab=cap1_4}
C {devices/lab_pin.sym} 120 -21820 0 0 {name=p578 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -22040 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -22420 0 0 {name=MSW1_5_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -22450 0 0 {name=p579 lab=bank1}
C {devices/lab_pin.sym} 100 -22420 0 0 {name=p580 lab=s5}
C {devices/lab_pin.sym} 140 -22390 0 0 {name=p581 lab=cap1_5}
C {devices/lab_pin.sym} 140 -22420 0 0 {name=p582 lab=0}
C {symbols/pfet_03v3.sym} 400 -22420 0 0 {name=MSW1_5_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -22390 0 0 {name=p583 lab=bank1}
C {devices/lab_pin.sym} 380 -22420 0 0 {name=p584 lab=s5bar}
C {devices/lab_pin.sym} 420 -22450 0 0 {name=p585 lab=cap1_5}
C {devices/lab_pin.sym} 420 -22420 0 0 {name=p586 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -22610 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -22990 0 0 {name=CC1_5_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -23020 0 0 {name=p587 lab=cap1_5}
C {devices/lab_pin.sym} 120 -22960 0 0 {name=p588 lab=0}
C {symbols/cap_mim_analog.sym} 400 -22990 0 0 {name=CC1_5_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -23020 0 0 {name=p589 lab=cap1_5}
C {devices/lab_pin.sym} 400 -22960 0 0 {name=p590 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -23180 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -23560 0 0 {name=MSW1_6_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -23590 0 0 {name=p591 lab=bank1}
C {devices/lab_pin.sym} 100 -23560 0 0 {name=p592 lab=s6}
C {devices/lab_pin.sym} 140 -23530 0 0 {name=p593 lab=cap1_6}
C {devices/lab_pin.sym} 140 -23560 0 0 {name=p594 lab=0}
C {symbols/pfet_03v3.sym} 400 -23560 0 0 {name=MSW1_6_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -23530 0 0 {name=p595 lab=bank1}
C {devices/lab_pin.sym} 380 -23560 0 0 {name=p596 lab=s6bar}
C {devices/lab_pin.sym} 420 -23590 0 0 {name=p597 lab=cap1_6}
C {devices/lab_pin.sym} 420 -23560 0 0 {name=p598 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -23750 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -24130 0 0 {name=CC1_6_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -24160 0 0 {name=p599 lab=cap1_6}
C {devices/lab_pin.sym} 120 -24100 0 0 {name=p600 lab=0}
C {symbols/cap_mim_analog.sym} 400 -24130 0 0 {name=CC1_6_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -24160 0 0 {name=p601 lab=cap1_6}
C {devices/lab_pin.sym} 400 -24100 0 0 {name=p602 lab=0}
C {symbols/cap_mim_analog.sym} 680 -24130 0 0 {name=CC1_6_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -24160 0 0 {name=p603 lab=cap1_6}
C {devices/lab_pin.sym} 680 -24100 0 0 {name=p604 lab=0}
C {symbols/cap_mim_analog.sym} 960 -24130 0 0 {name=CC1_6_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -24160 0 0 {name=p605 lab=cap1_6}
C {devices/lab_pin.sym} 960 -24100 0 0 {name=p606 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -24320 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -24700 0 0 {name=MSW1_7_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -24730 0 0 {name=p607 lab=bank1}
C {devices/lab_pin.sym} 100 -24700 0 0 {name=p608 lab=s7}
C {devices/lab_pin.sym} 140 -24670 0 0 {name=p609 lab=cap1_7}
C {devices/lab_pin.sym} 140 -24700 0 0 {name=p610 lab=0}
C {symbols/pfet_03v3.sym} 400 -24700 0 0 {name=MSW1_7_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -24670 0 0 {name=p611 lab=bank1}
C {devices/lab_pin.sym} 380 -24700 0 0 {name=p612 lab=s7bar}
C {devices/lab_pin.sym} 420 -24730 0 0 {name=p613 lab=cap1_7}
C {devices/lab_pin.sym} 420 -24700 0 0 {name=p614 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -24890 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -25270 0 0 {name=CC1_7_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -25300 0 0 {name=p615 lab=cap1_7}
C {devices/lab_pin.sym} 120 -25240 0 0 {name=p616 lab=0}
C {symbols/cap_mim_analog.sym} 400 -25270 0 0 {name=CC1_7_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -25300 0 0 {name=p617 lab=cap1_7}
C {devices/lab_pin.sym} 400 -25240 0 0 {name=p618 lab=0}
C {symbols/cap_mim_analog.sym} 680 -25270 0 0 {name=CC1_7_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -25300 0 0 {name=p619 lab=cap1_7}
C {devices/lab_pin.sym} 680 -25240 0 0 {name=p620 lab=0}
C {symbols/cap_mim_analog.sym} 960 -25270 0 0 {name=CC1_7_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -25300 0 0 {name=p621 lab=cap1_7}
C {devices/lab_pin.sym} 960 -25240 0 0 {name=p622 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -25270 0 0 {name=CC1_7_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -25300 0 0 {name=p623 lab=cap1_7}
C {devices/lab_pin.sym} 1240 -25240 0 0 {name=p624 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -25270 0 0 {name=CC1_7_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -25300 0 0 {name=p625 lab=cap1_7}
C {devices/lab_pin.sym} 1520 -25240 0 0 {name=p626 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -25270 0 0 {name=CC1_7_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -25300 0 0 {name=p627 lab=cap1_7}
C {devices/lab_pin.sym} 1800 -25240 0 0 {name=p628 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -25270 0 0 {name=CC1_7_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -25300 0 0 {name=p629 lab=cap1_7}
C {devices/lab_pin.sym} 2080 -25240 0 0 {name=p630 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -25460 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -25840 0 0 {name=MSW1_8_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -25870 0 0 {name=p631 lab=bank1}
C {devices/lab_pin.sym} 100 -25840 0 0 {name=p632 lab=s8}
C {devices/lab_pin.sym} 140 -25810 0 0 {name=p633 lab=cap1_8}
C {devices/lab_pin.sym} 140 -25840 0 0 {name=p634 lab=0}
C {symbols/pfet_03v3.sym} 400 -25840 0 0 {name=MSW1_8_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -25810 0 0 {name=p635 lab=bank1}
C {devices/lab_pin.sym} 380 -25840 0 0 {name=p636 lab=s8bar}
C {devices/lab_pin.sym} 420 -25870 0 0 {name=p637 lab=cap1_8}
C {devices/lab_pin.sym} 420 -25840 0 0 {name=p638 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -26030 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -26410 0 0 {name=CC1_8_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -26440 0 0 {name=p639 lab=cap1_8}
C {devices/lab_pin.sym} 120 -26380 0 0 {name=p640 lab=0}
C {symbols/cap_mim_analog.sym} 400 -26410 0 0 {name=CC1_8_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -26440 0 0 {name=p641 lab=cap1_8}
C {devices/lab_pin.sym} 400 -26380 0 0 {name=p642 lab=0}
C {symbols/cap_mim_analog.sym} 680 -26410 0 0 {name=CC1_8_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -26440 0 0 {name=p643 lab=cap1_8}
C {devices/lab_pin.sym} 680 -26380 0 0 {name=p644 lab=0}
C {symbols/cap_mim_analog.sym} 960 -26410 0 0 {name=CC1_8_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -26440 0 0 {name=p645 lab=cap1_8}
C {devices/lab_pin.sym} 960 -26380 0 0 {name=p646 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -26410 0 0 {name=CC1_8_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -26440 0 0 {name=p647 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -26380 0 0 {name=p648 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -26410 0 0 {name=CC1_8_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -26440 0 0 {name=p649 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -26380 0 0 {name=p650 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -26410 0 0 {name=CC1_8_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -26440 0 0 {name=p651 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -26380 0 0 {name=p652 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -26410 0 0 {name=CC1_8_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -26440 0 0 {name=p653 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -26380 0 0 {name=p654 lab=0}
C {symbols/cap_mim_analog.sym} 120 -26600 0 0 {name=CC1_8_8_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -26630 0 0 {name=p655 lab=cap1_8}
C {devices/lab_pin.sym} 120 -26570 0 0 {name=p656 lab=0}
C {symbols/cap_mim_analog.sym} 400 -26600 0 0 {name=CC1_8_9_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -26630 0 0 {name=p657 lab=cap1_8}
C {devices/lab_pin.sym} 400 -26570 0 0 {name=p658 lab=0}
C {symbols/cap_mim_analog.sym} 680 -26600 0 0 {name=CC1_8_10_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -26630 0 0 {name=p659 lab=cap1_8}
C {devices/lab_pin.sym} 680 -26570 0 0 {name=p660 lab=0}
C {symbols/cap_mim_analog.sym} 960 -26600 0 0 {name=CC1_8_11_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -26630 0 0 {name=p661 lab=cap1_8}
C {devices/lab_pin.sym} 960 -26570 0 0 {name=p662 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -26600 0 0 {name=CC1_8_12_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -26630 0 0 {name=p663 lab=cap1_8}
C {devices/lab_pin.sym} 1240 -26570 0 0 {name=p664 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -26600 0 0 {name=CC1_8_13_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -26630 0 0 {name=p665 lab=cap1_8}
C {devices/lab_pin.sym} 1520 -26570 0 0 {name=p666 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -26600 0 0 {name=CC1_8_14_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -26630 0 0 {name=p667 lab=cap1_8}
C {devices/lab_pin.sym} 1800 -26570 0 0 {name=p668 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -26600 0 0 {name=CC1_8_15_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -26630 0 0 {name=p669 lab=cap1_8}
C {devices/lab_pin.sym} 2080 -26570 0 0 {name=p670 lab=0}
T {RING — PDK symbols; nets use named labels} 80 -26790 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -27170 0 0 {name=MINV2_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -27200 0 0 {name=p671 lab=d2}
C {devices/lab_pin.sym} 100 -27170 0 0 {name=p672 lab=n1}
C {devices/lab_pin.sym} 140 -27140 0 0 {name=p673 lab=0}
C {devices/lab_pin.sym} 140 -27170 0 0 {name=p674 lab=0}
C {symbols/pfet_03v3.sym} 400 -27170 0 0 {name=MINV2_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -27140 0 0 {name=p675 lab=d2}
C {devices/lab_pin.sym} 380 -27170 0 0 {name=p676 lab=n1}
C {devices/lab_pin.sym} 420 -27200 0 0 {name=p677 lab=vdd}
C {devices/lab_pin.sym} 420 -27170 0 0 {name=p678 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -27360 0 0 0.35 0.35 {}
C {symbols/ppolyf_u_1k.sym} 120 -27740 0 0 {name=RRDELAY2 model=ppolyf_u_1k W=1u L=440u m=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -27770 0 0 {name=p679 lab=d2}
C {devices/lab_pin.sym} 120 -27710 0 0 {name=p680 lab=n2}
C {devices/lab_pin.sym} 100 -27740 0 0 {name=p681 lab=0}
C {symbols/cap_mim_analog.sym} 400 -27740 0 0 {name=CCBASE2 model=cap_mim_2f0_m4m5_noshield m=1 W=15.6u L=15.6u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -27770 0 0 {name=p682 lab=n2}
C {devices/lab_pin.sym} 400 -27710 0 0 {name=p683 lab=0}
T {MASTER — PDK symbols; nets use named labels} 80 -27930 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -28310 0 0 {name=MMAIN2_N L=0.28u W=8u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -28340 0 0 {name=p684 lab=n2}
C {devices/lab_pin.sym} 100 -28310 0 0 {name=p685 lab=smain}
C {devices/lab_pin.sym} 140 -28280 0 0 {name=p686 lab=bank2}
C {devices/lab_pin.sym} 140 -28310 0 0 {name=p687 lab=0}
C {symbols/pfet_03v3.sym} 400 -28310 0 0 {name=MMAIN2_P L=0.28u W=16u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -28280 0 0 {name=p688 lab=n2}
C {devices/lab_pin.sym} 380 -28310 0 0 {name=p689 lab=smainbar}
C {devices/lab_pin.sym} 420 -28340 0 0 {name=p690 lab=bank2}
C {devices/lab_pin.sym} 420 -28310 0 0 {name=p691 lab=vdd}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -28500 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -28880 0 0 {name=MSW2_0_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -28910 0 0 {name=p692 lab=bank2}
C {devices/lab_pin.sym} 100 -28880 0 0 {name=p693 lab=s0}
C {devices/lab_pin.sym} 140 -28850 0 0 {name=p694 lab=cap2_0}
C {devices/lab_pin.sym} 140 -28880 0 0 {name=p695 lab=0}
C {symbols/pfet_03v3.sym} 400 -28880 0 0 {name=MSW2_0_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -28850 0 0 {name=p696 lab=bank2}
C {devices/lab_pin.sym} 380 -28880 0 0 {name=p697 lab=s0bar}
C {devices/lab_pin.sym} 420 -28910 0 0 {name=p698 lab=cap2_0}
C {devices/lab_pin.sym} 420 -28880 0 0 {name=p699 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -29070 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -29450 0 0 {name=CC2_0_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -29480 0 0 {name=p700 lab=cap2_0}
C {devices/lab_pin.sym} 120 -29420 0 0 {name=p701 lab=mid2_0_0_0}
C {symbols/cap_mim_analog.sym} 400 -29450 0 0 {name=CC2_0_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -29480 0 0 {name=p702 lab=mid2_0_0_0}
C {devices/lab_pin.sym} 400 -29420 0 0 {name=p703 lab=mid2_0_0_1}
C {symbols/cap_mim_analog.sym} 680 -29450 0 0 {name=CC2_0_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -29480 0 0 {name=p704 lab=mid2_0_0_1}
C {devices/lab_pin.sym} 680 -29420 0 0 {name=p705 lab=mid2_0_0_2}
C {symbols/cap_mim_analog.sym} 960 -29450 0 0 {name=CC2_0_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -29480 0 0 {name=p706 lab=mid2_0_0_2}
C {devices/lab_pin.sym} 960 -29420 0 0 {name=p707 lab=mid2_0_0_3}
C {symbols/cap_mim_analog.sym} 1240 -29450 0 0 {name=CC2_0_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -29480 0 0 {name=p708 lab=mid2_0_0_3}
C {devices/lab_pin.sym} 1240 -29420 0 0 {name=p709 lab=mid2_0_0_4}
C {symbols/cap_mim_analog.sym} 1520 -29450 0 0 {name=CC2_0_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -29480 0 0 {name=p710 lab=mid2_0_0_4}
C {devices/lab_pin.sym} 1520 -29420 0 0 {name=p711 lab=mid2_0_0_5}
C {symbols/cap_mim_analog.sym} 1800 -29450 0 0 {name=CC2_0_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -29480 0 0 {name=p712 lab=mid2_0_0_5}
C {devices/lab_pin.sym} 1800 -29420 0 0 {name=p713 lab=mid2_0_0_6}
C {symbols/cap_mim_analog.sym} 2080 -29450 0 0 {name=CC2_0_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -29480 0 0 {name=p714 lab=mid2_0_0_6}
C {devices/lab_pin.sym} 2080 -29420 0 0 {name=p715 lab=mid2_0_0_7}
C {symbols/cap_mim_analog.sym} 120 -29640 0 0 {name=CC2_0_0_8 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -29670 0 0 {name=p716 lab=mid2_0_0_7}
C {devices/lab_pin.sym} 120 -29610 0 0 {name=p717 lab=mid2_0_0_8}
C {symbols/cap_mim_analog.sym} 400 -29640 0 0 {name=CC2_0_0_9 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -29670 0 0 {name=p718 lab=mid2_0_0_8}
C {devices/lab_pin.sym} 400 -29610 0 0 {name=p719 lab=mid2_0_0_9}
C {symbols/cap_mim_analog.sym} 680 -29640 0 0 {name=CC2_0_0_10 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -29670 0 0 {name=p720 lab=mid2_0_0_9}
C {devices/lab_pin.sym} 680 -29610 0 0 {name=p721 lab=mid2_0_0_10}
C {symbols/cap_mim_analog.sym} 960 -29640 0 0 {name=CC2_0_0_11 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -29670 0 0 {name=p722 lab=mid2_0_0_10}
C {devices/lab_pin.sym} 960 -29610 0 0 {name=p723 lab=mid2_0_0_11}
C {symbols/cap_mim_analog.sym} 1240 -29640 0 0 {name=CC2_0_0_12 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -29670 0 0 {name=p724 lab=mid2_0_0_11}
C {devices/lab_pin.sym} 1240 -29610 0 0 {name=p725 lab=mid2_0_0_12}
C {symbols/cap_mim_analog.sym} 1520 -29640 0 0 {name=CC2_0_0_13 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -29670 0 0 {name=p726 lab=mid2_0_0_12}
C {devices/lab_pin.sym} 1520 -29610 0 0 {name=p727 lab=mid2_0_0_13}
C {symbols/cap_mim_analog.sym} 1800 -29640 0 0 {name=CC2_0_0_14 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -29670 0 0 {name=p728 lab=mid2_0_0_13}
C {devices/lab_pin.sym} 1800 -29610 0 0 {name=p729 lab=mid2_0_0_14}
C {symbols/cap_mim_analog.sym} 2080 -29640 0 0 {name=CC2_0_0_15 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -29670 0 0 {name=p730 lab=mid2_0_0_14}
C {devices/lab_pin.sym} 2080 -29610 0 0 {name=p731 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -29830 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -30210 0 0 {name=MSW2_1_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -30240 0 0 {name=p732 lab=bank2}
C {devices/lab_pin.sym} 100 -30210 0 0 {name=p733 lab=s1}
C {devices/lab_pin.sym} 140 -30180 0 0 {name=p734 lab=cap2_1}
C {devices/lab_pin.sym} 140 -30210 0 0 {name=p735 lab=0}
C {symbols/pfet_03v3.sym} 400 -30210 0 0 {name=MSW2_1_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -30180 0 0 {name=p736 lab=bank2}
C {devices/lab_pin.sym} 380 -30210 0 0 {name=p737 lab=s1bar}
C {devices/lab_pin.sym} 420 -30240 0 0 {name=p738 lab=cap2_1}
C {devices/lab_pin.sym} 420 -30210 0 0 {name=p739 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -30400 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -30780 0 0 {name=CC2_1_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -30810 0 0 {name=p740 lab=cap2_1}
C {devices/lab_pin.sym} 120 -30750 0 0 {name=p741 lab=mid2_1_0_0}
C {symbols/cap_mim_analog.sym} 400 -30780 0 0 {name=CC2_1_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -30810 0 0 {name=p742 lab=mid2_1_0_0}
C {devices/lab_pin.sym} 400 -30750 0 0 {name=p743 lab=mid2_1_0_1}
C {symbols/cap_mim_analog.sym} 680 -30780 0 0 {name=CC2_1_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -30810 0 0 {name=p744 lab=mid2_1_0_1}
C {devices/lab_pin.sym} 680 -30750 0 0 {name=p745 lab=mid2_1_0_2}
C {symbols/cap_mim_analog.sym} 960 -30780 0 0 {name=CC2_1_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -30810 0 0 {name=p746 lab=mid2_1_0_2}
C {devices/lab_pin.sym} 960 -30750 0 0 {name=p747 lab=mid2_1_0_3}
C {symbols/cap_mim_analog.sym} 1240 -30780 0 0 {name=CC2_1_0_4 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -30810 0 0 {name=p748 lab=mid2_1_0_3}
C {devices/lab_pin.sym} 1240 -30750 0 0 {name=p749 lab=mid2_1_0_4}
C {symbols/cap_mim_analog.sym} 1520 -30780 0 0 {name=CC2_1_0_5 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -30810 0 0 {name=p750 lab=mid2_1_0_4}
C {devices/lab_pin.sym} 1520 -30750 0 0 {name=p751 lab=mid2_1_0_5}
C {symbols/cap_mim_analog.sym} 1800 -30780 0 0 {name=CC2_1_0_6 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -30810 0 0 {name=p752 lab=mid2_1_0_5}
C {devices/lab_pin.sym} 1800 -30750 0 0 {name=p753 lab=mid2_1_0_6}
C {symbols/cap_mim_analog.sym} 2080 -30780 0 0 {name=CC2_1_0_7 model=cap_mim_2f0_m4m5_noshield m=1 W=5.0u L=5.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -30810 0 0 {name=p754 lab=mid2_1_0_6}
C {devices/lab_pin.sym} 2080 -30750 0 0 {name=p755 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -30970 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -31350 0 0 {name=MSW2_2_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -31380 0 0 {name=p756 lab=bank2}
C {devices/lab_pin.sym} 100 -31350 0 0 {name=p757 lab=s2}
C {devices/lab_pin.sym} 140 -31320 0 0 {name=p758 lab=cap2_2}
C {devices/lab_pin.sym} 140 -31350 0 0 {name=p759 lab=0}
C {symbols/pfet_03v3.sym} 400 -31350 0 0 {name=MSW2_2_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -31320 0 0 {name=p760 lab=bank2}
C {devices/lab_pin.sym} 380 -31350 0 0 {name=p761 lab=s2bar}
C {devices/lab_pin.sym} 420 -31380 0 0 {name=p762 lab=cap2_2}
C {devices/lab_pin.sym} 420 -31350 0 0 {name=p763 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -31540 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -31920 0 0 {name=CC2_2_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -31950 0 0 {name=p764 lab=cap2_2}
C {devices/lab_pin.sym} 120 -31890 0 0 {name=p765 lab=mid2_2_0_0}
C {symbols/cap_mim_analog.sym} 400 -31920 0 0 {name=CC2_2_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -31950 0 0 {name=p766 lab=mid2_2_0_0}
C {devices/lab_pin.sym} 400 -31890 0 0 {name=p767 lab=mid2_2_0_1}
C {symbols/cap_mim_analog.sym} 680 -31920 0 0 {name=CC2_2_0_2 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -31950 0 0 {name=p768 lab=mid2_2_0_1}
C {devices/lab_pin.sym} 680 -31890 0 0 {name=p769 lab=mid2_2_0_2}
C {symbols/cap_mim_analog.sym} 960 -31920 0 0 {name=CC2_2_0_3 model=cap_mim_2f0_m4m5_noshield m=1 W=6.0u L=6.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -31950 0 0 {name=p770 lab=mid2_2_0_2}
C {devices/lab_pin.sym} 960 -31890 0 0 {name=p771 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -32110 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -32490 0 0 {name=MSW2_3_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -32520 0 0 {name=p772 lab=bank2}
C {devices/lab_pin.sym} 100 -32490 0 0 {name=p773 lab=s3}
C {devices/lab_pin.sym} 140 -32460 0 0 {name=p774 lab=cap2_3}
C {devices/lab_pin.sym} 140 -32490 0 0 {name=p775 lab=0}
C {symbols/pfet_03v3.sym} 400 -32490 0 0 {name=MSW2_3_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -32460 0 0 {name=p776 lab=bank2}
C {devices/lab_pin.sym} 380 -32490 0 0 {name=p777 lab=s3bar}
C {devices/lab_pin.sym} 420 -32520 0 0 {name=p778 lab=cap2_3}
C {devices/lab_pin.sym} 420 -32490 0 0 {name=p779 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -32680 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -33060 0 0 {name=CC2_3_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -33090 0 0 {name=p780 lab=cap2_3}
C {devices/lab_pin.sym} 120 -33030 0 0 {name=p781 lab=mid2_3_0_0}
C {symbols/cap_mim_analog.sym} 400 -33060 0 0 {name=CC2_3_0_1 model=cap_mim_2f0_m4m5_noshield m=1 W=6.5u L=6.5u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -33090 0 0 {name=p782 lab=mid2_3_0_0}
C {devices/lab_pin.sym} 400 -33030 0 0 {name=p783 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -33250 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -33630 0 0 {name=MSW2_4_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -33660 0 0 {name=p784 lab=bank2}
C {devices/lab_pin.sym} 100 -33630 0 0 {name=p785 lab=s4}
C {devices/lab_pin.sym} 140 -33600 0 0 {name=p786 lab=cap2_4}
C {devices/lab_pin.sym} 140 -33630 0 0 {name=p787 lab=0}
C {symbols/pfet_03v3.sym} 400 -33630 0 0 {name=MSW2_4_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -33600 0 0 {name=p788 lab=bank2}
C {devices/lab_pin.sym} 380 -33630 0 0 {name=p789 lab=s4bar}
C {devices/lab_pin.sym} 420 -33660 0 0 {name=p790 lab=cap2_4}
C {devices/lab_pin.sym} 420 -33630 0 0 {name=p791 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -33820 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -34200 0 0 {name=CC2_4_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.7u L=6.7u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -34230 0 0 {name=p792 lab=cap2_4}
C {devices/lab_pin.sym} 120 -34170 0 0 {name=p793 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -34390 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -34770 0 0 {name=MSW2_5_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -34800 0 0 {name=p794 lab=bank2}
C {devices/lab_pin.sym} 100 -34770 0 0 {name=p795 lab=s5}
C {devices/lab_pin.sym} 140 -34740 0 0 {name=p796 lab=cap2_5}
C {devices/lab_pin.sym} 140 -34770 0 0 {name=p797 lab=0}
C {symbols/pfet_03v3.sym} 400 -34770 0 0 {name=MSW2_5_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -34740 0 0 {name=p798 lab=bank2}
C {devices/lab_pin.sym} 380 -34770 0 0 {name=p799 lab=s5bar}
C {devices/lab_pin.sym} 420 -34800 0 0 {name=p800 lab=cap2_5}
C {devices/lab_pin.sym} 420 -34770 0 0 {name=p801 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -34960 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -35340 0 0 {name=CC2_5_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -35370 0 0 {name=p802 lab=cap2_5}
C {devices/lab_pin.sym} 120 -35310 0 0 {name=p803 lab=0}
C {symbols/cap_mim_analog.sym} 400 -35340 0 0 {name=CC2_5_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.8u L=6.8u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -35370 0 0 {name=p804 lab=cap2_5}
C {devices/lab_pin.sym} 400 -35310 0 0 {name=p805 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -35530 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -35910 0 0 {name=MSW2_6_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -35940 0 0 {name=p806 lab=bank2}
C {devices/lab_pin.sym} 100 -35910 0 0 {name=p807 lab=s6}
C {devices/lab_pin.sym} 140 -35880 0 0 {name=p808 lab=cap2_6}
C {devices/lab_pin.sym} 140 -35910 0 0 {name=p809 lab=0}
C {symbols/pfet_03v3.sym} 400 -35910 0 0 {name=MSW2_6_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -35880 0 0 {name=p810 lab=bank2}
C {devices/lab_pin.sym} 380 -35910 0 0 {name=p811 lab=s6bar}
C {devices/lab_pin.sym} 420 -35940 0 0 {name=p812 lab=cap2_6}
C {devices/lab_pin.sym} 420 -35910 0 0 {name=p813 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -36100 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -36480 0 0 {name=CC2_6_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -36510 0 0 {name=p814 lab=cap2_6}
C {devices/lab_pin.sym} 120 -36450 0 0 {name=p815 lab=0}
C {symbols/cap_mim_analog.sym} 400 -36480 0 0 {name=CC2_6_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -36510 0 0 {name=p816 lab=cap2_6}
C {devices/lab_pin.sym} 400 -36450 0 0 {name=p817 lab=0}
C {symbols/cap_mim_analog.sym} 680 -36480 0 0 {name=CC2_6_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -36510 0 0 {name=p818 lab=cap2_6}
C {devices/lab_pin.sym} 680 -36450 0 0 {name=p819 lab=0}
C {symbols/cap_mim_analog.sym} 960 -36480 0 0 {name=CC2_6_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=6.9u L=6.9u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -36510 0 0 {name=p820 lab=cap2_6}
C {devices/lab_pin.sym} 960 -36450 0 0 {name=p821 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -36670 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -37050 0 0 {name=MSW2_7_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -37080 0 0 {name=p822 lab=bank2}
C {devices/lab_pin.sym} 100 -37050 0 0 {name=p823 lab=s7}
C {devices/lab_pin.sym} 140 -37020 0 0 {name=p824 lab=cap2_7}
C {devices/lab_pin.sym} 140 -37050 0 0 {name=p825 lab=0}
C {symbols/pfet_03v3.sym} 400 -37050 0 0 {name=MSW2_7_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -37020 0 0 {name=p826 lab=bank2}
C {devices/lab_pin.sym} 380 -37050 0 0 {name=p827 lab=s7bar}
C {devices/lab_pin.sym} 420 -37080 0 0 {name=p828 lab=cap2_7}
C {devices/lab_pin.sym} 420 -37050 0 0 {name=p829 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -37240 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -37620 0 0 {name=CC2_7_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -37650 0 0 {name=p830 lab=cap2_7}
C {devices/lab_pin.sym} 120 -37590 0 0 {name=p831 lab=0}
C {symbols/cap_mim_analog.sym} 400 -37620 0 0 {name=CC2_7_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -37650 0 0 {name=p832 lab=cap2_7}
C {devices/lab_pin.sym} 400 -37590 0 0 {name=p833 lab=0}
C {symbols/cap_mim_analog.sym} 680 -37620 0 0 {name=CC2_7_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -37650 0 0 {name=p834 lab=cap2_7}
C {devices/lab_pin.sym} 680 -37590 0 0 {name=p835 lab=0}
C {symbols/cap_mim_analog.sym} 960 -37620 0 0 {name=CC2_7_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -37650 0 0 {name=p836 lab=cap2_7}
C {devices/lab_pin.sym} 960 -37590 0 0 {name=p837 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -37620 0 0 {name=CC2_7_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -37650 0 0 {name=p838 lab=cap2_7}
C {devices/lab_pin.sym} 1240 -37590 0 0 {name=p839 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -37620 0 0 {name=CC2_7_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -37650 0 0 {name=p840 lab=cap2_7}
C {devices/lab_pin.sym} 1520 -37590 0 0 {name=p841 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -37620 0 0 {name=CC2_7_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -37650 0 0 {name=p842 lab=cap2_7}
C {devices/lab_pin.sym} 1800 -37590 0 0 {name=p843 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -37620 0 0 {name=CC2_7_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -37650 0 0 {name=p844 lab=cap2_7}
C {devices/lab_pin.sym} 2080 -37590 0 0 {name=p845 lab=0}
T {BRANCH SWITCH — PDK symbols; nets use named labels} 80 -37810 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -38190 0 0 {name=MSW2_8_N L=0.28u W=1u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -38220 0 0 {name=p846 lab=bank2}
C {devices/lab_pin.sym} 100 -38190 0 0 {name=p847 lab=s8}
C {devices/lab_pin.sym} 140 -38160 0 0 {name=p848 lab=cap2_8}
C {devices/lab_pin.sym} 140 -38190 0 0 {name=p849 lab=0}
C {symbols/pfet_03v3.sym} 400 -38190 0 0 {name=MSW2_8_P L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -38160 0 0 {name=p850 lab=bank2}
C {devices/lab_pin.sym} 380 -38190 0 0 {name=p851 lab=s8bar}
C {devices/lab_pin.sym} 420 -38220 0 0 {name=p852 lab=cap2_8}
C {devices/lab_pin.sym} 420 -38190 0 0 {name=p853 lab=vdd}
T {PASSIVES — PDK symbols; nets use named labels} 80 -38380 0 0 0.35 0.35 {}
C {symbols/cap_mim_analog.sym} 120 -38760 0 0 {name=CC2_8_0_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -38790 0 0 {name=p854 lab=cap2_8}
C {devices/lab_pin.sym} 120 -38730 0 0 {name=p855 lab=0}
C {symbols/cap_mim_analog.sym} 400 -38760 0 0 {name=CC2_8_1_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -38790 0 0 {name=p856 lab=cap2_8}
C {devices/lab_pin.sym} 400 -38730 0 0 {name=p857 lab=0}
C {symbols/cap_mim_analog.sym} 680 -38760 0 0 {name=CC2_8_2_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -38790 0 0 {name=p858 lab=cap2_8}
C {devices/lab_pin.sym} 680 -38730 0 0 {name=p859 lab=0}
C {symbols/cap_mim_analog.sym} 960 -38760 0 0 {name=CC2_8_3_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -38790 0 0 {name=p860 lab=cap2_8}
C {devices/lab_pin.sym} 960 -38730 0 0 {name=p861 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -38760 0 0 {name=CC2_8_4_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -38790 0 0 {name=p862 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -38730 0 0 {name=p863 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -38760 0 0 {name=CC2_8_5_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -38790 0 0 {name=p864 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -38730 0 0 {name=p865 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -38760 0 0 {name=CC2_8_6_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -38790 0 0 {name=p866 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -38730 0 0 {name=p867 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -38760 0 0 {name=CC2_8_7_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -38790 0 0 {name=p868 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -38730 0 0 {name=p869 lab=0}
C {symbols/cap_mim_analog.sym} 120 -38950 0 0 {name=CC2_8_8_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -38980 0 0 {name=p870 lab=cap2_8}
C {devices/lab_pin.sym} 120 -38920 0 0 {name=p871 lab=0}
C {symbols/cap_mim_analog.sym} 400 -38950 0 0 {name=CC2_8_9_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 400 -38980 0 0 {name=p872 lab=cap2_8}
C {devices/lab_pin.sym} 400 -38920 0 0 {name=p873 lab=0}
C {symbols/cap_mim_analog.sym} 680 -38950 0 0 {name=CC2_8_10_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 680 -38980 0 0 {name=p874 lab=cap2_8}
C {devices/lab_pin.sym} 680 -38920 0 0 {name=p875 lab=0}
C {symbols/cap_mim_analog.sym} 960 -38950 0 0 {name=CC2_8_11_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 960 -38980 0 0 {name=p876 lab=cap2_8}
C {devices/lab_pin.sym} 960 -38920 0 0 {name=p877 lab=0}
C {symbols/cap_mim_analog.sym} 1240 -38950 0 0 {name=CC2_8_12_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1240 -38980 0 0 {name=p878 lab=cap2_8}
C {devices/lab_pin.sym} 1240 -38920 0 0 {name=p879 lab=0}
C {symbols/cap_mim_analog.sym} 1520 -38950 0 0 {name=CC2_8_13_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1520 -38980 0 0 {name=p880 lab=cap2_8}
C {devices/lab_pin.sym} 1520 -38920 0 0 {name=p881 lab=0}
C {symbols/cap_mim_analog.sym} 1800 -38950 0 0 {name=CC2_8_14_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1800 -38980 0 0 {name=p882 lab=cap2_8}
C {devices/lab_pin.sym} 1800 -38920 0 0 {name=p883 lab=0}
C {symbols/cap_mim_analog.sym} 2080 -38950 0 0 {name=CC2_8_15_0 model=cap_mim_2f0_m4m5_noshield m=1 W=7.0u L=7.0u MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2080 -38980 0 0 {name=p884 lab=cap2_8}
C {devices/lab_pin.sym} 2080 -38920 0 0 {name=p885 lab=0}
T {BUFFER — PDK symbols; nets use named labels} 80 -39140 0 0 0.35 0.35 {}
C {symbols/nfet_03v3.sym} 120 -39520 0 0 {name=MBUF0_N L=0.28u W=2u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 140 -39550 0 0 {name=p886 lab=buf}
C {devices/lab_pin.sym} 100 -39520 0 0 {name=p887 lab=d2}
C {devices/lab_pin.sym} 140 -39490 0 0 {name=p888 lab=0}
C {devices/lab_pin.sym} 140 -39520 0 0 {name=p889 lab=0}
C {symbols/pfet_03v3.sym} 400 -39520 0 0 {name=MBUF0_P L=0.28u W=4u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 420 -39490 0 0 {name=p890 lab=buf}
C {devices/lab_pin.sym} 380 -39520 0 0 {name=p891 lab=d2}
C {devices/lab_pin.sym} 420 -39550 0 0 {name=p892 lab=vdd}
C {devices/lab_pin.sym} 420 -39520 0 0 {name=p893 lab=vdd}
C {symbols/nfet_03v3.sym} 680 -39520 0 0 {name=MBUF1_N L=0.28u W=8u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 700 -39550 0 0 {name=p894 lab=clk}
C {devices/lab_pin.sym} 660 -39520 0 0 {name=p895 lab=buf}
C {devices/lab_pin.sym} 700 -39490 0 0 {name=p896 lab=0}
C {devices/lab_pin.sym} 700 -39520 0 0 {name=p897 lab=0}
C {symbols/pfet_03v3.sym} 960 -39520 0 0 {name=MBUF1_P L=0.28u W=16u nf=1 m=1 mult=1 ad=0 as=0 pd=0 ps=0 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_03v3 spiceprefix=X}
C {devices/lab_pin.sym} 980 -39490 0 0 {name=p898 lab=clk}
C {devices/lab_pin.sym} 940 -39520 0 0 {name=p899 lab=buf}
C {devices/lab_pin.sym} 980 -39550 0 0 {name=p900 lab=vdd}
C {devices/lab_pin.sym} 980 -39520 0 0 {name=p901 lab=vdd}
